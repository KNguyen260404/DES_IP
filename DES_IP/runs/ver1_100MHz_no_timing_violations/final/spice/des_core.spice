* NGSPICE file created from des_core.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_1 abstract view
.subckt sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_1 abstract view
.subckt sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_8 abstract view
.subckt sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

.subckt des_core VGND VPWR clk des_data[0] des_data[10] des_data[11] des_data[12]
+ des_data[13] des_data[14] des_data[15] des_data[16] des_data[17] des_data[18] des_data[19]
+ des_data[1] des_data[20] des_data[21] des_data[22] des_data[23] des_data[24] des_data[25]
+ des_data[26] des_data[27] des_data[28] des_data[29] des_data[2] des_data[30] des_data[31]
+ des_data[32] des_data[33] des_data[34] des_data[35] des_data[36] des_data[37] des_data[38]
+ des_data[39] des_data[3] des_data[40] des_data[41] des_data[42] des_data[43] des_data[44]
+ des_data[45] des_data[46] des_data[47] des_data[48] des_data[49] des_data[4] des_data[50]
+ des_data[51] des_data[52] des_data[53] des_data[54] des_data[55] des_data[56] des_data[57]
+ des_data[58] des_data[59] des_data[5] des_data[60] des_data[61] des_data[62] des_data[63]
+ des_data[6] des_data[7] des_data[8] des_data[9] des_decipher_en des_encipher_en
+ des_key_in[0] des_key_in[10] des_key_in[11] des_key_in[12] des_key_in[13] des_key_in[14]
+ des_key_in[15] des_key_in[16] des_key_in[17] des_key_in[18] des_key_in[19] des_key_in[1]
+ des_key_in[20] des_key_in[21] des_key_in[22] des_key_in[23] des_key_in[24] des_key_in[25]
+ des_key_in[26] des_key_in[27] des_key_in[28] des_key_in[29] des_key_in[2] des_key_in[30]
+ des_key_in[31] des_key_in[32] des_key_in[33] des_key_in[34] des_key_in[35] des_key_in[36]
+ des_key_in[37] des_key_in[38] des_key_in[39] des_key_in[3] des_key_in[40] des_key_in[41]
+ des_key_in[42] des_key_in[43] des_key_in[44] des_key_in[45] des_key_in[46] des_key_in[47]
+ des_key_in[48] des_key_in[49] des_key_in[4] des_key_in[50] des_key_in[51] des_key_in[52]
+ des_key_in[53] des_key_in[54] des_key_in[55] des_key_in[56] des_key_in[57] des_key_in[58]
+ des_key_in[59] des_key_in[5] des_key_in[60] des_key_in[61] des_key_in[62] des_key_in[63]
+ des_key_in[6] des_key_in[7] des_key_in[8] des_key_in[9] desc_ready desc_result[0]
+ desc_result[10] desc_result[11] desc_result[12] desc_result[13] desc_result[14]
+ desc_result[15] desc_result[16] desc_result[17] desc_result[18] desc_result[19]
+ desc_result[1] desc_result[20] desc_result[21] desc_result[22] desc_result[23] desc_result[24]
+ desc_result[25] desc_result[26] desc_result[27] desc_result[28] desc_result[29]
+ desc_result[2] desc_result[30] desc_result[31] desc_result[32] desc_result[33] desc_result[34]
+ desc_result[35] desc_result[36] desc_result[37] desc_result[38] desc_result[39]
+ desc_result[3] desc_result[40] desc_result[41] desc_result[42] desc_result[43] desc_result[44]
+ desc_result[45] desc_result[46] desc_result[47] desc_result[48] desc_result[49]
+ desc_result[4] desc_result[50] desc_result[51] desc_result[52] desc_result[53] desc_result[54]
+ desc_result[55] desc_result[56] desc_result[57] desc_result[58] desc_result[59]
+ desc_result[5] desc_result[60] desc_result[61] desc_result[62] desc_result[63] desc_result[6]
+ desc_result[7] desc_result[8] desc_result[9] rst_n
X_2106_ _0431_ _0435_ net215 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__mux2_1
X_2037_ _0390_ _0389_ net200 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1270_ cn\[2\] _0665_ _0666_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__and3b_2
X_1606_ net191 _0994_ _0823_ _0820_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a2bb2o_1
X_1537_ _0898_ _0899_ _0902_ _0903_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__o22ai_1
X_1468_ cn\[8\] _0860_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__and3b_1
X_1399_ net142 net17 net220 VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__mux2_1
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1253_ net5 net237 net230 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__and3b_1
X_1322_ cn_dn\[11\] _0717_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__and3b_2
X_1184_ net53 net238 net231 VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_19_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1871_ rcounter\[2\] rcounter\[1\] VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__nand2_1
X_1940_ cn\[8\] _0313_ net224 VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__mux2_1
XFILLER_56_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1305_ net195 _0692_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__a21oi_1
X_2285_ clknet_4_14_0_clk _0069_ VGND VGND VPWR VPWR cn_dn\[1\] sky130_fd_sc_hd__dfxtp_1
X_1236_ _0597_ _0615_ _0616_ _0625_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a31o_1
XFILLER_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1167_ _0544_ _0549_ _0551_ _0530_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__o211a_1
XFILLER_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2070_ cn_dn\[6\] _0417_ net226 VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__mux2_1
XFILLER_19_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1785_ _0174_ _0176_ _0925_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_44_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1923_ _0295_ _0299_ net198 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__mux2_1
X_1854_ net193 net192 _0775_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__a21oi_1
XFILLER_37_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2268_ clknet_4_4_0_clk _0052_ VGND VGND VPWR VPWR cn\[12\] sky130_fd_sc_hd__dfxtp_2
X_2199_ net146 _0667_ net240 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__mux2_1
X_1219_ _0598_ _0615_ _0616_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__and3_1
X_2337_ clknet_4_0_0_clk _0121_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dfxtp_1
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_5 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1570_ _0617_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__nor2_1
X_2122_ cn_dn\[19\] net86 net206 VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__mux2_1
X_2053_ _0399_ _0403_ net202 VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1906_ _0281_ _0277_ net212 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__mux2_1
X_1837_ _0919_ _0935_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__and3_1
X_1768_ _0590_ _0629_ _0165_ _0621_ _0587_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__a221o_1
XFILLER_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1699_ _0901_ _0917_ _0932_ _1079_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__o211ai_1
XFILLER_25_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput120 des_key_in[6] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1622_ net143 _1009_ net244 VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__mux2_1
X_1553_ _0702_ _0944_ _0677_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__and3b_1
X_1484_ _0852_ _0853_ _0863_ _0865_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__and4_1
X_2105_ cn_dn\[13\] _0445_ net227 VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__mux2_1
X_2036_ cn_dn\[1\] net108 net206 VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1536_ _0900_ _0910_ _0905_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__mux2_1
X_1605_ _0803_ _0814_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__xnor2_1
X_1398_ _0758_ _0793_ _0790_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__mux2_1
X_1467_ net49 net234 net232 VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__or3_4
XFILLER_42_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2019_ cn\[24\] _0376_ net222 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__mux2_1
XFILLER_10_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1252_ net237 net230 net128 VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__a21oi_1
X_1321_ net47 net235 net233 VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__or3_2
X_1183_ net238 net231 net176 VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_19_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1519_ _0905_ _0910_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1870_ rcounter\[0\] rcounter\[3\] VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__nand2_1
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1304_ _0680_ _0684_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__nand2_1
X_1166_ _0531_ _0543_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__nor2_1
X_1235_ _0590_ _0633_ _0626_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__a21oi_1
X_2284_ clknet_4_11_0_clk _0068_ VGND VGND VPWR VPWR cn_dn\[0\] sky130_fd_sc_hd__dfxtp_1
X_1999_ _0358_ _0360_ net249 VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__mux2_1
XFILLER_18_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1922_ cn\[7\] net93 net205 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1784_ _0932_ _1080_ _0179_ _0180_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__o211a_1
X_1853_ net193 _0776_ net192 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__or3_1
X_2336_ clknet_4_7_0_clk _0120_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dfxtp_1
XFILLER_29_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2267_ clknet_4_4_0_clk _0051_ VGND VGND VPWR VPWR cn\[11\] sky130_fd_sc_hd__dfxtp_4
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1218_ _0615_ _0616_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__and2_1
X_2198_ net155 _0679_ net239 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__mux2_1
X_1149_ _0547_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__or2_2
XFILLER_52_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2052_ cn_dn\[5\] net107 net206 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux2_1
X_2121_ _0443_ _0447_ net216 VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
X_1905_ cn\[1\] _0285_ net228 VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1698_ _0901_ _0917_ _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__o21a_1
X_1836_ _0904_ _0911_ net189 VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1767_ _0597_ _0603_ _0613_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__a21o_1
X_2319_ clknet_4_15_0_clk _0103_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput110 des_key_in[54] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
Xinput121 des_key_in[7] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1621_ _1007_ _1008_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__xnor2_1
X_1552_ _0672_ _0674_ _0648_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__a21o_1
X_2104_ _0442_ _0444_ net254 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__mux2_1
X_1483_ _0867_ _0872_ _0854_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__or3b_1
XFILLER_54_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2035_ cn_dn\[2\] net100 net208 VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1819_ _0832_ _0211_ _0212_ _0209_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__a31o_1
XFILLER_45_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1535_ _0900_ _0910_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__nand2_1
X_1604_ _0816_ _0822_ _0837_ _0988_ _0825_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__o311a_1
XFILLER_27_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1466_ net236 net229 net172 VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__a21o_2
X_1397_ _0761_ _0785_ _0792_ _0759_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__a211o_1
X_2018_ _0374_ _0375_ net249 VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__mux2_1
XFILLER_37_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1320_ net238 net231 net170 VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a21o_1
XFILLER_5_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1251_ cn\[9\] _0647_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__xnor2_4
XFILLER_38_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1182_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1518_ cn_dn\[25\] _0909_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__xnor2_4
X_1449_ net132 _0843_ net243 VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__mux2_1
XFILLER_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1303_ _0648_ _0663_ _0672_ _0678_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__a22o_1
X_2283_ clknet_4_3_0_clk _0067_ VGND VGND VPWR VPWR cn\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1165_ _0528_ _0529_ _0547_ _0548_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__o2bb2ai_1
X_1234_ _0604_ _0631_ _0629_ _0625_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a211o_1
X_1998_ _0355_ _0359_ net197 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__mux2_1
XFILLER_55_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1921_ _0283_ _0287_ net212 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__mux2_1
X_1852_ _0777_ _0781_ _0784_ _1034_ _0756_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a221o_1
X_1783_ _0906_ _0927_ _0914_ _0894_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__o211a_1
X_2266_ clknet_4_4_0_clk _0050_ VGND VGND VPWR VPWR cn\[10\] sky130_fd_sc_hd__dfxtp_1
X_2335_ clknet_4_0_0_clk _0119_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dfxtp_1
X_2197_ net241 _0855_ _0856_ _0504_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_35_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1217_ _0601_ _0602_ _0608_ _0610_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__or4_2
X_1148_ _0545_ _0546_ cn_dn\[17\] VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_58_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2120_ cn_dn\[16\] _0457_ net227 VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__mux2_1
XFILLER_20_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2051_ _0390_ _0389_ net213 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__mux2_1
X_1904_ _0282_ _0284_ net250 VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1835_ net148 _0227_ net240 VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__mux2_1
X_1697_ _0904_ _0911_ _0900_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a21o_1
X_1766_ _0623_ _0636_ _0163_ _0585_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__o211a_1
X_2249_ clknet_4_5_0_clk _0000_ net123 VGND VGND VPWR VPWR k16_calculation sky130_fd_sc_hd__dfrtp_1
X_2318_ clknet_4_9_0_clk _0102_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
Xinput122 des_key_in[9] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
Xinput111 des_key_in[55] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_1
Xinput100 des_key_in[44] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1620_ net144 net19 net221 VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__mux2_1
X_1551_ net125 net247 _0942_ _0943_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__a22o_1
X_1482_ _0869_ _0874_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__xnor2_1
XFILLER_54_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2103_ _0439_ _0443_ net201 VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__mux2_1
XFILLER_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2034_ _0386_ _0387_ net213 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1818_ _0799_ _0838_ _1069_ _0991_ _0797_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__a32oi_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1749_ _0147_ _0148_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__xnor2_1
XFILLER_60_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1534_ _0901_ _0911_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__nand2_1
X_1465_ _0852_ _0853_ _0857_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__a211oi_2
X_1603_ _0797_ _0799_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__nor3_1
XFILLER_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2017_ _0371_ _0273_ net197 VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__mux2_1
X_1396_ _0763_ _0777_ _0791_ _0757_ _0756_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__o2111a_1
XFILLER_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1250_ cn\[9\] _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__xor2_2
X_1181_ cn\[23\] _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_19_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1517_ cn_dn\[25\] _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__xor2_4
X_1448_ _0841_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__xnor2_1
XFILLER_55_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1379_ _0765_ _0766_ _0771_ _0772_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__nor4_2
XFILLER_23_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1302_ _0672_ _0674_ _0656_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__a21o_1
X_2282_ clknet_4_3_0_clk _0066_ VGND VGND VPWR VPWR cn\[26\] sky130_fd_sc_hd__dfxtp_1
X_1233_ _0594_ _0596_ _0608_ _0610_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a211o_1
XFILLER_52_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1164_ _0531_ _0550_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__nor2_1
X_1997_ cn\[22\] net103 net203 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__mux2_1
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1920_ cn\[4\] _0297_ net224 VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__mux2_1
X_1851_ _0763_ _0239_ _0240_ _0241_ _0762_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a311oi_1
X_1782_ _0901_ _0904_ _0906_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__or3_1
X_2334_ clknet_4_6_0_clk _0118_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dfxtp_1
X_2196_ net164 _0509_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__and2_1
X_2265_ clknet_4_5_0_clk _0049_ VGND VGND VPWR VPWR cn\[9\] sky130_fd_sc_hd__dfxtp_2
X_1216_ _0601_ _0602_ _0609_ _0611_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_40_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1147_ cn_dn\[17\] _0545_ _0546_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__and3b_1
XFILLER_20_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ cn_dn\[2\] _0401_ net225 VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__mux2_1
XFILLER_22_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1903_ _0278_ _0283_ net198 VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1834_ _0225_ _0226_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__xnor2_1
X_1765_ _0590_ _1046_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nand2_1
X_1696_ _0901_ _0906_ _0917_ _0921_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__o311a_1
X_2248_ clknet_4_5_0_clk net66 net123 VGND VGND VPWR VPWR encipher_en_sync sky130_fd_sc_hd__dfrtp_1
XFILLER_25_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2179_ net243 _0538_ _0539_ _0499_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__a31o_1
X_2317_ clknet_4_10_0_clk _0101_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dfxtp_1
XFILLER_40_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput123 rst_n VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_4
Xinput101 des_key_in[45] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
Xinput112 des_key_in[57] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_1
XFILLER_56_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1550_ _0940_ _0941_ net244 VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__o21a_1
X_1481_ _0866_ _0868_ _0872_ _0859_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a211o_1
X_2102_ cn_dn\[15\] net90 net209 VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__mux2_1
XFILLER_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2033_ cn_dn\[27\] net76 net208 VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__mux2_1
XFILLER_22_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1748_ net138 net13 net218 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__mux2_1
X_1817_ _0210_ _0829_ _0824_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__or3b_1
X_1679_ _0649_ _0663_ _0673_ _0655_ _0700_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__o221a_1
XFILLER_53_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1602_ _0989_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__xnor2_1
X_1464_ _0855_ _0856_ cn\[1\] VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a21boi_2
X_1533_ _0900_ _0910_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nor2_1
X_1395_ _0768_ _0781_ _0776_ net193 VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__a211o_1
X_2016_ _0359_ _0363_ net211 VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__mux2_1
XFILLER_10_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1180_ net156 net33 net219 VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__mux2_4
XFILLER_17_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1516_ net126 net3 net219 VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_10_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1447_ net133 net8 net220 VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__mux2_1
X_1378_ _0771_ _0772_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__nor2_1
XFILLER_48_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1301_ _0696_ _0697_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nor3_1
XFILLER_37_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1232_ _0598_ _0612_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nor2_1
X_2281_ clknet_4_3_0_clk _0065_ VGND VGND VPWR VPWR cn\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1163_ _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__inv_2
XFILLER_20_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1996_ _0343_ _0347_ net210 VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__mux2_1
XFILLER_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload0 clknet_4_0_0_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__bufinv_16
XFILLER_59_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1781_ net189 _0931_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nand2_1
X_1850_ _0239_ _0240_ _0763_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__a21oi_1
X_2333_ clknet_4_7_0_clk _0117_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dfxtp_1
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2264_ clknet_4_4_0_clk _0048_ VGND VGND VPWR VPWR cn\[8\] sky130_fd_sc_hd__dfxtp_1
X_2195_ net239 _0860_ _0861_ _0503_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a31o_1
X_1215_ _0601_ _0602_ _0608_ _0610_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__o22a_1
X_1146_ net64 net234 net232 VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__or3_1
XFILLER_25_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1979_ _0342_ _0344_ net248 VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__mux2_1
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1902_ cn\[3\] net105 net205 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__mux2_1
XFILLER_34_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1833_ net149 net24 net217 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__mux2_1
X_1764_ _0636_ _0160_ _0965_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__a21o_1
XFILLER_57_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1695_ _0901_ _0906_ _0917_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__o21ai_1
X_2316_ clknet_4_11_0_clk _0100_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dfxtp_1
X_2247_ clknet_4_5_0_clk _0033_ net123 VGND VGND VPWR VPWR decipher_process sky130_fd_sc_hd__dfrtp_1
X_1129_ _0525_ _0526_ cn_dn\[7\] VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__o21ai_2
X_2178_ net133 net247 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__and2_1
XFILLER_40_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput113 des_key_in[58] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput102 des_key_in[46] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XFILLER_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ _0871_ _0872_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2101_ _0427_ _0431_ net215 VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2032_ cn_dn\[26\] net122 net206 VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1747_ _0141_ _0143_ _0146_ _0138_ _0740_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1678_ _0690_ _1061_ _1059_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__o21ai_1
X_1816_ _0807_ _0835_ _0826_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_15_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1532_ _0894_ _0914_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__nor2_1
XFILLER_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1601_ _0803_ _0822_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__xnor2_1
X_1463_ cn\[1\] _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__and3b_1
X_1394_ _0777_ net192 _0789_ _0756_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a211o_1
XFILLER_50_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2015_ cn\[23\] _0373_ net222 VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__mux2_1
XFILLER_5_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1515_ _0900_ _0905_ net189 VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_10_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1446_ _0830_ _0833_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__o21ai_1
X_1377_ _0771_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or2_2
XFILLER_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1300_ _0680_ _0685_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__or2_1
X_2280_ clknet_4_3_0_clk _0064_ VGND VGND VPWR VPWR cn\[24\] sky130_fd_sc_hd__dfxtp_1
X_1162_ _0518_ _0522_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__and2_1
X_1231_ _0609_ _0611_ _0593_ _0595_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a211o_1
X_1995_ cn\[19\] _0357_ net222 VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__mux2_1
X_1429_ _0817_ _0820_ _0823_ _0800_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a31o_1
XFILLER_11_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload1 clknet_4_1_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__bufinv_16
XFILLER_59_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_3_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1780_ _0908_ _0919_ _0931_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__a21o_1
X_2332_ clknet_4_3_0_clk _0116_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dfxtp_1
X_2263_ clknet_4_4_0_clk _0047_ VGND VGND VPWR VPWR cn\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1214_ _0608_ _0610_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__nor2_1
X_2194_ net173 net247 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__and2_1
X_1145_ net236 net229 net187 VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21o_1
XFILLER_60_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1978_ _0339_ _0343_ net196 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__mux2_1
XFILLER_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1832_ _0740_ _0144_ _0224_ _0223_ _0222_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a32o_1
X_1901_ _0272_ _0281_ net212 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_40_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1694_ net172 _1076_ net239 VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__mux2_1
X_1763_ _0638_ _0160_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__nor2_1
X_2315_ clknet_4_15_0_clk _0099_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dfxtp_1
X_2246_ clknet_4_9_0_clk _0032_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dfxtp_1
X_1128_ cn_dn\[7\] _0525_ _0526_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__or3_2
XFILLER_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2177_ net142 _0534_ net245 VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_46_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput114 des_key_in[59] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
Xinput103 des_key_in[47] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_1
XFILLER_8_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2100_ cn_dn\[12\] _0441_ net227 VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__mux2_1
X_2031_ cn\[27\] _0385_ net223 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1815_ _0816_ _0822_ _0837_ _0988_ _0831_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__o311a_1
X_1746_ _0713_ _0145_ _0741_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__o21a_1
X_1677_ net195 _0691_ _1060_ _1058_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__a31oi_1
XFILLER_7_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2229_ clknet_4_9_0_clk _0015_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dfxtp_1
XFILLER_5_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1462_ net40 net235 net233 VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__or3_2
X_1531_ _0908_ _0920_ _0923_ _0910_ _0921_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__o221a_1
XFILLER_8_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1600_ net190 _0812_ net191 VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a21o_1
X_1393_ _0786_ _0788_ _0781_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__o21a_1
XFILLER_50_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2014_ _0370_ _0372_ net249 VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__mux2_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1729_ _0531_ _0553_ _0983_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__nor3_1
XFILLER_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1514_ cn_dn\[4\] _0844_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__xnor2_1
X_1445_ _0832_ _0837_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_10_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1376_ _0769_ _0770_ cn\[22\] VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__a21boi_2
XFILLER_2_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1230_ _0597_ _0613_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nor2_1
X_1161_ _0518_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nor2_1
X_1994_ _0354_ _0356_ net248 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__mux2_1
X_1428_ _0803_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__nand2_1
X_1359_ net150 _0755_ net244 VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__mux2_1
XFILLER_28_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload2 clknet_4_2_0_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_21_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout250 net256 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_4
X_2262_ clknet_4_4_0_clk _0046_ VGND VGND VPWR VPWR cn\[6\] sky130_fd_sc_hd__dfxtp_1
X_1213_ _0609_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nand2_1
X_2331_ clknet_4_0_0_clk _0115_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dfxtp_1
X_2193_ net182 _0851_ net246 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__mux2_1
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1144_ _0535_ _0536_ _0540_ _0541_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_43_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1977_ cn\[18\] net71 net203 VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__mux2_1
XFILLER_51_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1831_ _0721_ _0218_ _0739_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_40_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1900_ cn\[0\] net84 net205 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__mux2_1
X_1693_ _1074_ _1075_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__xor2_1
X_1762_ _0630_ _0632_ _0614_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__a21o_1
X_2176_ net151 _0516_ net244 VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__mux2_1
X_2314_ clknet_4_8_0_clk _0098_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dfxtp_1
X_2245_ clknet_4_2_0_clk _0031_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dfxtp_1
X_1127_ _0525_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nor2_1
XFILLER_33_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput115 des_key_in[5] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput104 des_key_in[49] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_1
XFILLER_56_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ _0383_ _0384_ net248 VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__mux2_1
XFILLER_11_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1814_ net165 _0208_ net241 VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__mux2_1
X_1745_ _1010_ _0144_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__xor2_1
XFILLER_30_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1676_ _0659_ _0661_ _0668_ _0669_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__or4_1
X_2228_ clknet_4_13_0_clk _0014_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2159_ cn_dn\[24\] _0488_ net225 VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_8_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1461_ net237 net230 net163 VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__a21o_1
X_1530_ net189 _0922_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__nand2_1
X_1392_ net193 _0775_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__and2_1
X_2013_ _0367_ _0371_ net197 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__mux2_1
XFILLER_50_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1728_ _0530_ _0974_ _0128_ _0572_ _0518_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a221o_1
XFILLER_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1659_ net126 _1044_ net242 VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__mux2_1
XFILLER_41_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1513_ cn_dn\[4\] _0844_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__xor2_4
X_1444_ _0807_ _0835_ _0814_ net191 VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__o211a_1
X_1375_ cn\[22\] _0769_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__and3b_1
XFILLER_31_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1160_ _0558_ _0559_ _0530_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a21oi_1
XFILLER_60_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1993_ _0351_ _0355_ net196 VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__mux2_1
X_1358_ _0753_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__xnor2_1
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1427_ _0810_ _0811_ _0805_ _0806_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__o211a_1
X_1289_ _0648_ _0678_ _0686_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__o21ba_1
XFILLER_50_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload3 clknet_4_3_0_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinvlp_4
Xfanout240 net246 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_2
Xfanout251 net256 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_12_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2330_ clknet_4_7_0_clk _0114_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dfxtp_1
X_2261_ clknet_4_6_0_clk _0045_ VGND VGND VPWR VPWR cn\[5\] sky130_fd_sc_hd__dfxtp_1
X_1212_ _0605_ _0606_ cn\[27\] VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__o21ai_1
X_2192_ net158 _0844_ net242 VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__mux2_1
XFILLER_1_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1143_ _0535_ _0536_ _0540_ _0541_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__o22a_1
XFILLER_60_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1976_ _0327_ _0331_ net210 VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__mux2_1
XFILLER_29_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1761_ net128 _0159_ net241 VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__mux2_1
X_1830_ _0219_ _0220_ _0741_ _0217_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_40_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2313_ clknet_4_9_0_clk _0097_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dfxtp_1
X_1692_ net173 net48 net217 VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__mux2_1
X_1126_ net12 net238 net231 VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__and3b_1
X_2175_ net160 _0802_ net242 VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__mux2_1
X_2244_ clknet_4_2_0_clk _0030_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dfxtp_1
XFILLER_40_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1959_ _0326_ _0328_ net248 VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__mux2_1
Xinput105 des_key_in[4] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
Xinput116 des_key_in[60] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_60_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1813_ _0206_ _0207_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__xor2_1
X_1744_ _0725_ _0728_ _0726_ net194 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__o211ai_2
XFILLER_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1675_ _0685_ _0689_ _1058_ _0702_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__o31a_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2227_ clknet_4_13_0_clk _0013_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dfxtp_1
X_1109_ key_process _0509_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__and2_1
X_2089_ _0430_ _0432_ net254 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__mux2_1
XFILLER_26_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2158_ _0486_ _0487_ net252 VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1460_ _0852_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__nand2_1
X_1391_ _0763_ _0773_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ cn\[25\] net80 net203 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__mux2_1
XFILLER_50_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1658_ _1042_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__xnor2_1
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1727_ _0558_ _0537_ _0542_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__mux2_1
XFILLER_37_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ _0553_ _0564_ _0977_ _0978_ _0976_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__a221o_1
XFILLER_26_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1512_ _0902_ _0903_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__nor2_1
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1443_ _0801_ _0807_ _0835_ _0836_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__o31a_1
X_1374_ net51 net234 net232 VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__or3_1
XFILLER_23_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1992_ cn\[21\] net111 net204 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload10 clknet_4_10_0_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinv_4
XFILLER_20_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1357_ net151 net26 net221 VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_50_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1288_ _0680_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__nand2_1
X_1426_ _0816_ _0818_ _0820_ _0803_ _0815_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_38_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload4 clknet_4_4_0_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_21_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout241 net246 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
Xfanout230 net231 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_4
Xfanout252 net255 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_4
XFILLER_1_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2260_ clknet_4_4_0_clk _0044_ VGND VGND VPWR VPWR cn\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_34_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2191_ net127 _0909_ net240 VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__mux2_1
X_1211_ _0605_ _0606_ cn\[27\] VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__o21a_1
X_1142_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__nor2_2
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1975_ cn\[15\] _0341_ net222 VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__mux2_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1409_ cn_dn\[6\] _0802_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__xnor2_4
XFILLER_28_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_7_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1760_ _0150_ _0158_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_40_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1691_ _0831_ _1071_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__o21ba_1
X_2312_ clknet_4_8_0_clk _0096_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dfxtp_1
X_1125_ net238 net231 net125 VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21oi_2
X_2243_ clknet_4_2_0_clk _0029_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dfxtp_1
X_2174_ net245 _0808_ _0809_ _0498_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a31o_1
XFILLER_33_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1889_ net250 _0264_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__nor2_1
X_1958_ _0323_ _0327_ net196 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__mux2_1
Xinput106 des_key_in[50] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_1
Xinput117 des_key_in[61] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1812_ net166 net41 net218 VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__mux2_1
X_1743_ net194 _1014_ _0142_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__a21o_1
X_1674_ _0655_ _0670_ _0674_ _0649_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__o211a_1
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2226_ clknet_4_10_0_clk _0012_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1108_ net251 encipher_process VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__or2_1
X_2088_ _0427_ _0431_ net202 VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__mux2_1
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2157_ _0483_ _0386_ net200 VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1390_ net193 _0775_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nor2_1
X_2011_ _0355_ _0359_ net211 VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__mux2_1
XFILLER_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1657_ net127 net2 net218 VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__mux2_1
X_1726_ net154 _1106_ net239 VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__mux2_1
X_1588_ _0537_ _0549_ _0543_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__a21oi_1
XFILLER_37_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2209_ net149 _0607_ net240 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__mux2_1
XFILLER_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1511_ _0902_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__or2_4
X_1442_ _0801_ net190 _0835_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__o31ai_2
X_1373_ net236 net229 net174 VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_18_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1709_ net163 _1090_ net241 VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__mux2_1
XFILLER_2_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload11 clknet_4_11_0_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinv_4
X_1991_ _0339_ _0343_ net210 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__mux2_1
X_1425_ net190 _0812_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__nand2_1
X_1356_ _0741_ _0752_ _0749_ _0738_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__a2bb2o_1
X_1287_ cn\[5\] _0683_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_38_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload5 clknet_4_5_0_clk VGND VGND VPWR VPWR clkload5/X sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_21_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout231 _0514_ VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_4
XFILLER_46_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout253 net255 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_29_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout220 net221 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__clkbuf_4
Xfanout242 net243 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__clkbuf_4
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2190_ net244 _0896_ _0897_ _0502_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a31o_1
XFILLER_52_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1210_ cn\[27\] _0605_ _0606_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__or3_1
X_1141_ _0538_ _0539_ cn_dn\[0\] VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a21boi_2
XFILLER_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1974_ _0338_ _0340_ net248 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_23_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1408_ cn_dn\[6\] _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__xor2_4
X_1339_ _0716_ _0721_ _0729_ _0731_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__o22a_1
XFILLER_28_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1690_ _0994_ _1072_ _0815_ _0831_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__o211a_1
X_2242_ clknet_4_8_0_clk _0028_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dfxtp_1
X_2311_ clknet_4_11_0_clk _0095_ VGND VGND VPWR VPWR cn_dn\[27\] sky130_fd_sc_hd__dfxtp_1
X_1124_ _0518_ _0522_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__or2_2
X_2173_ net168 net247 VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__and2_1
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1957_ cn\[14\] net102 net203 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__mux2_1
X_1888_ _0261_ _0269_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__nand2_1
XFILLER_0_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput107 des_key_in[51] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_1
Xinput118 des_key_in[62] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1811_ _0696_ _0702_ _0205_ _0204_ _0200_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__o32a_1
XFILLER_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1742_ _0715_ _0733_ _0750_ _0744_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__a31o_1
X_1673_ _1056_ _0686_ _1055_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__nor3b_1
X_2225_ clknet_4_11_0_clk _0011_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1107_ net250 encipher_process VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__nor2_2
X_2087_ cn_dn\[12\] net113 net207 VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__mux2_1
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2156_ _0470_ _0475_ net213 VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_10_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2010_ cn\[22\] _0369_ net222 VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__mux2_1
XFILLER_50_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1725_ _1104_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__xnor2_1
X_1656_ _1032_ _1039_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__a21o_1
X_1587_ _0540_ _0541_ _0571_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__or3_1
X_2139_ _0471_ _0472_ net252 VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__mux2_1
X_2208_ net157 _0579_ net243 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__mux2_1
XFILLER_1_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1510_ _0709_ _0710_ cn_dn\[9\] VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__a21boi_1
XFILLER_4_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1441_ _0801_ _0814_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__or2_1
X_1372_ _0765_ _0766_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_18_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1708_ _1088_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__xor2_1
X_1639_ net134 _1025_ net244 VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__mux2_1
XFILLER_58_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1990_ cn\[18\] _0353_ net222 VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__mux2_1
Xclkload12 clknet_4_12_0_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__bufinv_16
X_1355_ _0715_ _0735_ _0750_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__a31o_1
X_1424_ net190 _0812_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2_1
X_1286_ cn\[5\] _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_38_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload6 clknet_4_6_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_21_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout254 net255 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_4
Xfanout210 net212 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_29_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout221 _0515_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__buf_4
Xfanout243 net245 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_4
Xfanout232 _0513_ VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_12_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1140_ cn_dn\[0\] _0538_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and3b_2
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1973_ _0335_ _0339_ net196 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__mux2_1
X_1338_ _0725_ _0728_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__or2_2
XFILLER_28_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1407_ net159 net36 net219 VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__mux2_4
X_1269_ _0665_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__and2_2
XFILLER_43_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2241_ clknet_4_5_0_clk _0027_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dfxtp_1
X_2310_ clknet_4_12_0_clk _0094_ VGND VGND VPWR VPWR cn_dn\[26\] sky130_fd_sc_hd__dfxtp_2
X_2172_ net177 _0584_ net243 VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1123_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__inv_2
X_1887_ rcounter\[2\] rcounter\[1\] _0259_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__or3b_1
X_1956_ _0311_ _0315_ net210 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__mux2_1
Xinput108 des_key_in[52] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput119 des_key_in[63] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1741_ _0712_ _0139_ _0140_ _0708_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__or4b_1
X_1810_ net195 _0674_ _0695_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__a21oi_1
X_1672_ net195 _0664_ _0688_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__and3_1
XFILLER_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2224_ clknet_4_15_0_clk _0010_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2155_ cn_dn\[23\] _0485_ net225 VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__mux2_1
XFILLER_53_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2086_ _0415_ _0419_ net214 VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__mux2_1
XFILLER_21_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput90 des_key_in[34] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__buf_1
X_1939_ _0310_ _0312_ net250 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__mux2_1
XFILLER_21_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1724_ net155 net30 net217 VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__mux2_1
XFILLER_58_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1586_ _0517_ _0522_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__or2_1
X_1655_ _0784_ _1031_ _1040_ _0759_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o211a_1
X_2207_ net166 _0779_ net241 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__mux2_1
X_2069_ _0414_ _0416_ net254 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__mux2_1
X_2138_ _0467_ _0470_ net200 VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__mux2_1
XFILLER_49_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1440_ _0804_ _0812_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__xnor2_2
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1371_ _0765_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__or2_2
XFILLER_31_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1638_ _1023_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__xnor2_1
X_1707_ net164 net39 net218 VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__mux2_1
XFILLER_58_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1569_ _0590_ _0632_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__nand2_1
XFILLER_54_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload13 clknet_4_13_0_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinvlp_4
X_1354_ _0733_ _0750_ _0715_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a21oi_1
X_1285_ _0681_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__and2_1
XFILLER_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1423_ net191 _0813_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nand2_1
XFILLER_48_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload7 clknet_4_7_0_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_21_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout200 net202 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
Xfanout211 net212 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_2
Xfanout222 net223 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_4
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout233 _0513_ VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_2
Xfanout255 net256 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_29_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1972_ cn\[17\] net79 net203 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1268_ net22 net235 net233 VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__or3_2
X_1337_ _0725_ _0728_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__nor2_1
X_1406_ cn_dn\[14\] _0516_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__xnor2_2
XFILLER_51_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1199_ _0593_ _0595_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__nor2_1
XFILLER_51_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1122_ cn_dn\[12\] _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__xnor2_2
X_2240_ clknet_4_0_0_clk _0026_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dfxtp_1
X_2171_ cn_dn\[27\] _0497_ net225 VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__mux2_1
XFILLER_25_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1886_ rcounter\[3\] _0267_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__xor2_1
X_1955_ cn\[11\] _0325_ net222 VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__mux2_1
Xinput109 des_key_in[53] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1740_ _0733_ _0750_ _0747_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__a21oi_1
X_1671_ net195 _0691_ _0951_ _0676_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a22o_1
XFILLER_30_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2223_ clknet_4_13_0_clk _0009_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dfxtp_1
X_2085_ cn_dn\[9\] _0429_ net226 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__mux2_1
X_2154_ _0482_ _0484_ net252 VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__mux2_1
XFILLER_53_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput91 des_key_in[35] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_1
X_1938_ _0307_ _0311_ net198 VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__mux2_1
X_1869_ net185 _0258_ net242 VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__mux2_1
Xinput80 des_key_in[23] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_48_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1654_ _0784_ _1030_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__nand2_1
X_1723_ _1095_ _1099_ _1101_ _1103_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__a31o_1
X_2206_ net239 _0769_ _0770_ _0506_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__a31o_1
X_1585_ _0568_ _0570_ _0974_ _0562_ _0557_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__o311a_1
X_2068_ _0411_ _0415_ net201 VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__mux2_1
X_2137_ _0455_ _0459_ net213 VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__mux2_1
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1370_ _0681_ _0682_ cn\[7\] VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__a21boi_2
X_1637_ net135 net10 net221 VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__mux2_1
X_1706_ _1078_ _1082_ _1085_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__o31a_1
X_1568_ _0625_ _0629_ _0631_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__or3_1
X_1499_ _0891_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__xor2_1
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload14 clknet_4_14_0_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__bufinv_16
X_1422_ _0804_ net190 VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nand2_1
XFILLER_55_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1353_ _0726_ _0731_ _0729_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__a21o_1
X_1284_ net60 net235 net233 VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or3_1
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload8 clknet_4_8_0_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__clkinvlp_4
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_4
Xfanout201 net202 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__clkbuf_4
Xfanout256 decipher_process VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__buf_2
Xfanout212 net216 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_4
Xfanout223 net228 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_2
Xfanout234 _0512_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_29_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1971_ _0323_ _0327_ net210 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__mux2_1
X_1405_ cn_dn\[14\] _0516_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__xor2_1
Xinput1 des_data[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_1336_ _0726_ _0729_ _0731_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nand3_2
X_1267_ net237 net230 net145 VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__a21o_1
X_1198_ _0594_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__nand2_2
XFILLER_51_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_27_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1121_ _0519_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__and2_1
XFILLER_25_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2170_ _0495_ _0496_ net252 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__mux2_1
X_1954_ _0322_ _0324_ net248 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__mux2_1
X_1885_ _0260_ _0265_ _0268_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__o21a_1
XFILLER_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1319_ cn_dn\[16\] _0714_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__xnor2_2
X_2299_ clknet_4_12_0_clk _0083_ VGND VGND VPWR VPWR cn_dn\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1670_ net147 _1054_ net242 VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__mux2_1
XFILLER_7_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2222_ clknet_4_15_0_clk _0008_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dfxtp_1
X_2084_ _0426_ _0428_ net255 VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__mux2_1
X_2153_ _0479_ _0483_ net200 VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1937_ cn\[10\] net70 net205 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__mux2_1
XFILLER_21_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput70 des_key_in[13] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
Xinput92 des_key_in[36] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_1
X_1868_ _0256_ _0257_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__xor2_1
Xinput81 des_key_in[25] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_1
X_1799_ _0524_ _0190_ _0192_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__a31o_1
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1584_ _0559_ _0542_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1722_ _0776_ _0786_ _1028_ _1102_ _0759_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__o311a_1
X_1653_ _0760_ _1033_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__and3_1
X_2205_ net175 net247 VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__and2_1
XFILLER_53_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2067_ cn_dn\[8\] net83 net207 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_14_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2136_ cn_dn\[22\] net97 net208 VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__mux2_1
XFILLER_1_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1705_ _1084_ _1086_ _0937_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__o21ai_1
XFILLER_31_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1636_ _0741_ _1016_ _1020_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__a31o_1
X_1567_ _0629_ _0631_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__nor2_1
XFILLER_54_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2119_ _0454_ _0456_ net254 VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1498_ net188 net63 net219 VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__mux2_1
XFILLER_22_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1421_ _0804_ net190 VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__and2_1
XFILLER_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1352_ _0743_ _0744_ _0745_ _0748_ _0741_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__o311a_1
X_1283_ net237 net230 net183 VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__a21o_1
Xclkload9 clknet_4_9_0_clk VGND VGND VPWR VPWR clkload9/X sky130_fd_sc_hd__clkbuf_8
XFILLER_59_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout246 _0510_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_2
Xfanout235 _0512_ VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__buf_2
Xfanout224 net228 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_4
Xfanout202 _0276_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_4
Xfanout213 net215 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_4
X_1619_ _0848_ _0876_ _1005_ _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a22o_1
XFILLER_54_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1970_ cn\[14\] _0337_ net223 VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_43_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1335_ _0726_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__nand2_1
X_1404_ cn_dn\[10\] _0534_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__xor2_2
X_1266_ _0659_ _0661_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__nor2_1
Xinput2 des_data[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_1197_ _0591_ _0592_ cn\[17\] VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a21bo_1
XFILLER_3_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_2_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1120_ net55 net234 net232 VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__or3_2
XFILLER_18_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1884_ rcounter\[0\] key_process rcounter\[1\] rcounter\[2\] VGND VGND VPWR VPWR
+ _0268_ sky130_fd_sc_hd__a31o_1
XFILLER_33_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1953_ _0319_ _0323_ net196 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__mux2_1
X_1318_ cn_dn\[16\] _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__xor2_4
X_2298_ clknet_4_14_0_clk _0082_ VGND VGND VPWR VPWR cn_dn\[14\] sky130_fd_sc_hd__dfxtp_1
X_1249_ net169 net56 net217 VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__mux2_8
XFILLER_24_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput180 net180 VGND VGND VPWR VPWR desc_result[5] sky130_fd_sc_hd__buf_4
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2152_ cn_dn\[25\] net73 net208 VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__mux2_1
X_2221_ clknet_4_9_0_clk _0007_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dfxtp_1
X_2083_ _0423_ _0427_ net202 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__mux2_1
XFILLER_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1936_ _0295_ _0299_ net212 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__mux2_1
X_1867_ net186 net61 net219 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__mux2_1
XFILLER_21_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput82 des_key_in[26] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
Xinput93 des_key_in[37] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_1
Xinput60 des_data[63] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
Xinput71 des_key_in[14] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_1
X_1798_ _0572_ _0193_ _0524_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__a21oi_1
XFILLER_29_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1721_ _0768_ _0781_ _1096_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__a21o_1
XFILLER_11_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1583_ net170 _0973_ net244 VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__mux2_1
X_1652_ _0782_ _1034_ _1035_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__a211o_1
X_2204_ net184 _0683_ net241 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__mux2_1
XFILLER_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2135_ cn_dn\[19\] _0469_ net227 VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__mux2_1
X_2066_ _0399_ _0403_ net214 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__mux2_1
XFILLER_19_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1919_ _0294_ _0296_ net251 VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__mux2_1
XFILLER_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_31_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1704_ net189 _0915_ _0919_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__and3_1
X_1566_ net178 _0957_ net245 VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__mux2_1
XFILLER_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1635_ _0741_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__nor2_1
X_1497_ _0887_ _0890_ _0848_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__mux2_1
XFILLER_54_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2118_ _0451_ _0455_ net201 VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__mux2_1
X_2049_ _0398_ _0400_ net252 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1351_ _0735_ _0747_ _0746_ _0712_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__a211o_1
X_1420_ net191 _0804_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__or3b_1
X_1282_ cn\[20\] _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__xor2_4
XFILLER_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1618_ _0847_ _0881_ _0845_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__a21bo_1
X_1549_ _0940_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__nand2_1
Xfanout214 net215 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_4
Xfanout225 net228 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_29_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout203 net204 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_4
Xfanout236 net238 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_4
Xfanout247 _0509_ VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_4
XFILLER_54_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1265_ _0660_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__nand2_2
X_1334_ _0719_ _0720_ _0723_ _0724_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__o22ai_4
X_1403_ cn_dn\[10\] _0534_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput3 des_data[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
X_1196_ _0591_ _0592_ cn\[17\] VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__a21boi_1
XFILLER_59_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1883_ _0260_ _0265_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__nor2_1
X_1952_ cn\[13\] net110 net203 VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__mux2_1
XFILLER_56_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2297_ clknet_4_15_0_clk _0081_ VGND VGND VPWR VPWR cn_dn\[13\] sky130_fd_sc_hd__dfxtp_1
X_1248_ net167 _0646_ net242 VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__mux2_1
X_1317_ net152 net29 net220 VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__mux2_8
XFILLER_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1179_ net176 _0578_ net242 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__mux2_1
XFILLER_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput181 net181 VGND VGND VPWR VPWR desc_result[60] sky130_fd_sc_hd__buf_4
Xoutput170 net170 VGND VGND VPWR VPWR desc_result[50] sky130_fd_sc_hd__buf_4
XFILLER_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2082_ cn_dn\[11\] net96 net207 VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__mux2_1
XFILLER_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2151_ _0467_ _0470_ net213 VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__mux2_1
X_2220_ clknet_4_10_0_clk _0006_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dfxtp_1
X_1935_ cn\[7\] _0309_ net224 VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__mux2_1
Xinput72 des_key_in[15] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_1
X_1866_ _0255_ _0152_ _0848_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__mux2_1
Xinput61 des_data[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
Xinput50 des_data[54] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
X_1797_ _0530_ _0554_ _0556_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__or3b_1
Xinput83 des_key_in[27] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_1
Xinput94 des_key_in[38] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_1
XFILLER_29_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1720_ _0763_ _0777_ _1100_ _0762_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__a211o_1
X_1651_ _0764_ _0767_ _0780_ _0757_ _0756_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__a311o_1
X_1582_ _0971_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_53_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2065_ cn_dn\[5\] _0413_ net226 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__mux2_1
X_2134_ _0466_ _0468_ net252 VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__mux2_1
X_2203_ net180 _0647_ net239 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__mux2_1
X_1918_ _0291_ _0295_ net198 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__mux2_1
X_1849_ _0776_ net192 VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1634_ net194 _1018_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__xnor2_1
X_1703_ _0913_ _1083_ _1084_ _0894_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__o31a_1
X_1565_ _0955_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__xnor2_1
X_1496_ _0867_ _0870_ _0889_ _0888_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__o31a_1
X_2117_ cn_dn\[18\] net67 net206 VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__mux2_1
X_2048_ _0394_ _0399_ net202 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1350_ _0725_ _0728_ _0716_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__a21oi_2
X_1281_ net154 net31 net217 VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__mux2_8
XFILLER_51_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1617_ _0846_ _0890_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__a21oi_1
Xfanout204 net209 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_2
X_1548_ net136 net1 net221 VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__mux2_1
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__clkbuf_4
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__clkbuf_4
Xfanout215 net216 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__clkbuf_4
X_1479_ _0857_ _0858_ _0862_ _0864_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__or4_1
Xfanout248 net256 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_37_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1402_ cn_dn\[24\] _0588_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__xor2_4
Xinput4 des_data[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_1264_ _0657_ _0658_ cn\[24\] VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a21bo_1
X_1333_ _0719_ _0720_ _0723_ _0724_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__o22a_1
XFILLER_51_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1195_ cn\[17\] _0591_ _0592_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nand3b_1
XFILLER_10_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1882_ rcounter\[1\] _0265_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__xnor2_1
X_1951_ _0307_ _0311_ net210 VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1316_ _0708_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__nand2_1
X_2296_ clknet_4_12_0_clk _0080_ VGND VGND VPWR VPWR cn_dn\[12\] sky130_fd_sc_hd__dfxtp_1
X_1247_ _0644_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__xor2_1
X_1178_ _0576_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__xor2_1
XFILLER_12_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput182 net182 VGND VGND VPWR VPWR desc_result[61] sky130_fd_sc_hd__buf_4
Xoutput171 net171 VGND VGND VPWR VPWR desc_result[51] sky130_fd_sc_hd__buf_4
XFILLER_47_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput160 net160 VGND VGND VPWR VPWR desc_result[41] sky130_fd_sc_hd__buf_4
XFILLER_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2081_ _0411_ _0415_ net214 VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__mux2_1
X_2150_ cn_dn\[22\] _0481_ net225 VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__mux2_1
XFILLER_23_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1934_ _0306_ _0308_ net250 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__mux2_1
Xinput40 des_data[45] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
Xinput84 des_key_in[28] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
Xinput73 des_key_in[17] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_1
X_1865_ _0845_ _0153_ _0157_ _0846_ _0254_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a221o_1
Xinput62 des_data[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
Xinput95 des_key_in[39] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
Xinput51 des_data[55] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
X_1796_ _0518_ _0567_ _0191_ _0189_ _0563_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__o32a_1
XFILLER_29_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2279_ clknet_4_3_0_clk _0063_ VGND VGND VPWR VPWR cn\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1581_ net171 net46 net221 VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__mux2_1
XFILLER_7_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1650_ _0756_ _0757_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__or2_1
X_2202_ net129 _0652_ net241 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__mux2_1
X_2064_ _0410_ _0412_ net254 VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__mux2_1
X_2133_ _0463_ _0467_ net200 VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__mux2_1
X_1917_ cn\[6\] net101 net205 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__mux2_1
X_1779_ _0906_ _0929_ _0935_ _0927_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__o211a_1
X_1848_ _0775_ _0776_ net192 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__or3_1
XFILLER_57_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1564_ net179 net54 net221 VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__mux2_1
X_1633_ _1011_ _1012_ _1019_ _0712_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__o22a_1
X_1702_ _0919_ _0935_ net189 VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__a21oi_1
XFILLER_39_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1495_ _0859_ _0863_ _0865_ _0868_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_18_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2116_ _0439_ _0443_ net214 VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_1
X_2047_ cn_dn\[4\] net114 net206 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1280_ _0655_ _0674_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout238 _0511_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__buf_4
Xfanout205 net209 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__clkbuf_4
X_1547_ _0936_ _0938_ _0939_ _0934_ _0924_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__o32a_1
Xfanout216 _0270_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_2
Xfanout227 net228 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__buf_2
X_1616_ _0870_ _0885_ _0884_ _0882_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__o211a_1
X_1478_ _0857_ _0858_ _0863_ _0865_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__and4bb_1
Xfanout249 net256 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__buf_2
XFILLER_54_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1401_ net141 _0796_ net243 VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__mux2_1
Xinput5 des_data[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_1263_ _0657_ _0658_ cn\[24\] VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__a21boi_1
X_1332_ cn_dn\[5\] _0727_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__xnor2_4
X_1194_ cn\[17\] _0591_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__and3b_1
XFILLER_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1950_ cn\[10\] _0321_ net224 VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__mux2_1
XFILLER_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1881_ _0265_ _0266_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__and2_1
X_1315_ cn_dn\[26\] _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__xnor2_4
X_2295_ clknet_4_15_0_clk _0079_ VGND VGND VPWR VPWR cn_dn\[11\] sky130_fd_sc_hd__dfxtp_1
X_1246_ net168 net43 net219 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__mux2_1
X_1177_ net177 net52 net219 VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__mux2_1
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput150 net150 VGND VGND VPWR VPWR desc_result[32] sky130_fd_sc_hd__buf_4
Xoutput161 net161 VGND VGND VPWR VPWR desc_result[42] sky130_fd_sc_hd__buf_4
Xoutput183 net183 VGND VGND VPWR VPWR desc_result[62] sky130_fd_sc_hd__buf_4
Xoutput172 net172 VGND VGND VPWR VPWR desc_result[52] sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_6_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_53_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2080_ cn_dn\[8\] _0425_ net226 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__mux2_1
X_1933_ _0303_ _0307_ net198 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__mux2_1
XFILLER_21_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput74 des_key_in[18] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
Xinput41 des_data[46] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput96 des_key_in[3] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_1
Xinput85 des_key_in[29] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_1
X_1864_ _0870_ _0875_ _0882_ _0888_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__o211a_1
Xinput30 des_data[36] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
Xinput52 des_data[56] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
Xinput63 des_data[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
X_1795_ _0555_ _0187_ _0530_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__a21oi_1
XFILLER_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2278_ clknet_4_2_0_clk _0062_ VGND VGND VPWR VPWR cn\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1229_ _0580_ _0585_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1580_ _0966_ _0969_ _0970_ _0962_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__a31o_2
X_2201_ net241 _0657_ _0658_ _0505_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a31o_1
X_2132_ cn_dn\[21\] net104 net208 VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__mux2_1
X_2063_ _0407_ _0411_ net201 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__mux2_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1916_ _0278_ _0283_ net212 VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__mux2_1
X_1847_ net139 _0238_ net240 VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__mux2_1
X_1778_ _0917_ _0926_ net189 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_4_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1701_ _0912_ _0919_ _0932_ _0935_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__and4b_1
X_1632_ _1013_ _1018_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__xnor2_1
X_1563_ _0947_ _0949_ _0954_ _0945_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a31o_1
X_1494_ _0871_ _0878_ _0880_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__or3b_1
X_2115_ cn_dn\[15\] _0453_ net227 VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2046_ _0393_ _0390_ net215 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__mux2_1
XFILLER_13_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout228 _0275_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_2
X_1546_ _0927_ _0935_ _0916_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__a21oi_1
Xfanout206 net209 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_4
X_1477_ cn\[21\] _0679_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__xnor2_2
XFILLER_5_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1615_ net152 _1003_ net243 VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__mux2_1
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_4
Xfanout239 net246 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_59_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2029_ _0281_ _0277_ net199 VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__mux2_1
XFILLER_24_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1331_ cn_dn\[5\] _0727_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__xor2_4
XFILLER_5_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1400_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__xor2_1
X_1262_ cn\[24\] _0657_ _0658_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nand3b_2
XFILLER_36_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1193_ net7 net234 net232 VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__or3_2
Xinput6 des_data[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1529_ _0898_ _0899_ _0902_ _0903_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__or4_2
XFILLER_19_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1880_ rcounter\[0\] key_process VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__or2_1
XFILLER_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1314_ _0709_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__and2_2
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2294_ clknet_4_15_0_clk _0078_ VGND VGND VPWR VPWR cn_dn\[10\] sky130_fd_sc_hd__dfxtp_2
XPHY_EDGE_ROW_22_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1245_ _0637_ _0641_ _0643_ _0634_ _0628_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__o32a_1
X_1176_ _0575_ _0574_ _0524_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__mux2_1
XFILLER_32_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput184 net184 VGND VGND VPWR VPWR desc_result[63] sky130_fd_sc_hd__buf_4
Xoutput151 net151 VGND VGND VPWR VPWR desc_result[33] sky130_fd_sc_hd__buf_4
Xoutput162 net162 VGND VGND VPWR VPWR desc_result[43] sky130_fd_sc_hd__buf_4
Xoutput173 net173 VGND VGND VPWR VPWR desc_result[53] sky130_fd_sc_hd__buf_4
Xoutput140 net140 VGND VGND VPWR VPWR desc_result[23] sky130_fd_sc_hd__buf_4
XFILLER_23_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput20 des_data[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
X_1932_ cn\[9\] net78 net209 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__mux2_1
X_1863_ net130 net247 _0252_ _0253_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__a22o_1
Xinput31 des_data[37] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
Xinput75 des_key_in[19] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_1
Xinput42 des_data[47] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
Xinput86 des_key_in[2] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_1
Xinput97 des_key_in[41] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_1
Xinput53 des_data[57] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
Xinput64 des_data[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
X_1794_ _0976_ _0189_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__nand2b_1
X_2277_ clknet_4_4_0_clk _0061_ VGND VGND VPWR VPWR cn\[21\] sky130_fd_sc_hd__dfxtp_2
X_1228_ _0581_ _0586_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__nor2_1
XFILLER_52_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1159_ _0535_ _0536_ _0547_ _0548_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__o22ai_2
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2200_ net138 _0509_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__and2_1
X_2062_ cn_dn\[7\] net91 net206 VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__mux2_1
X_2131_ _0451_ _0455_ net214 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__mux2_1
XFILLER_19_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1777_ _0906_ _0927_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__nor2_1
X_1915_ cn\[3\] _0293_ net224 VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__mux2_1
X_1846_ _0236_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__xor2_1
XFILLER_8_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2329_ clknet_4_0_0_clk _0113_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dfxtp_1
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_4_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1631_ _0728_ _0722_ _0725_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__mux2_1
X_1700_ net189 _0926_ _1080_ _1081_ _0925_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__o311a_1
XFILLER_33_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1562_ _0684_ _0953_ _0680_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__o21ai_1
X_1493_ _0846_ _0876_ _0881_ _0882_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a221o_1
X_2114_ _0450_ _0452_ net254 VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__mux2_1
X_2045_ cn_dn\[1\] _0397_ net226 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1829_ _1017_ _0218_ _0221_ _0712_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__a211o_1
XFILLER_57_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1614_ _1001_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__xor2_1
Xfanout207 net209 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__clkbuf_2
XFILLER_39_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1545_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__inv_2
X_1476_ cn\[21\] _0679_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__xor2_4
Xfanout218 _0515_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__buf_4
Xfanout229 net231 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_4
XFILLER_39_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2028_ _0371_ _0273_ net211 VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__mux2_1
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1261_ cn\[24\] _0657_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__and3b_1
X_1330_ net161 net38 net220 VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__mux2_4
X_1192_ net236 net229 net130 VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a21o_1
Xinput7 des_data[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_42_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1459_ _0849_ _0850_ cn\[15\] VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__o21ai_2
X_1528_ _0894_ _0913_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__nor2_1
XFILLER_42_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1313_ net20 net235 net233 VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__or3_1
X_2293_ clknet_4_15_0_clk _0077_ VGND VGND VPWR VPWR cn_dn\[9\] sky130_fd_sc_hd__dfxtp_1
X_1244_ _0587_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nor2_1
X_1175_ _0530_ _0553_ _0568_ _0543_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_32_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput163 net163 VGND VGND VPWR VPWR desc_result[44] sky130_fd_sc_hd__buf_4
Xoutput152 net152 VGND VGND VPWR VPWR desc_result[34] sky130_fd_sc_hd__buf_4
Xoutput130 net130 VGND VGND VPWR VPWR desc_result[14] sky130_fd_sc_hd__buf_4
Xoutput141 net141 VGND VGND VPWR VPWR desc_result[24] sky130_fd_sc_hd__buf_4
Xoutput174 net174 VGND VGND VPWR VPWR desc_result[54] sky130_fd_sc_hd__buf_4
Xoutput185 net185 VGND VGND VPWR VPWR desc_result[6] sky130_fd_sc_hd__buf_4
XFILLER_46_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput54 des_data[58] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
Xinput10 des_data[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_1931_ _0291_ _0295_ net216 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__mux2_1
Xinput32 des_data[38] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
Xinput43 des_data[48] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
X_1862_ _0248_ _0250_ _0251_ net239 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o31a_1
Xinput21 des_data[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
X_1793_ _0555_ _0571_ _0187_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__a31o_1
Xinput65 des_decipher_en VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
Xinput98 des_key_in[42] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
Xinput87 des_key_in[30] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
Xinput76 des_key_in[1] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_1
XFILLER_37_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2276_ clknet_4_1_0_clk _0060_ VGND VGND VPWR VPWR cn\[20\] sky130_fd_sc_hd__dfxtp_2
X_1227_ _0613_ _0619_ _0625_ _0624_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__o31a_1
X_1158_ _0535_ _0536_ _0547_ _0548_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__or4_2
XFILLER_52_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2061_ _0394_ _0399_ net213 VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__mux2_1
X_2130_ cn_dn\[18\] _0465_ net228 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__mux2_1
X_1914_ _0290_ _0292_ net251 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__mux2_1
XFILLER_34_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1776_ net184 net59 net218 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__mux2_1
X_1845_ net140 net15 net217 VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__mux2_1
XFILLER_8_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2328_ clknet_4_7_0_clk _0112_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dfxtp_1
X_2259_ clknet_4_6_0_clk _0043_ VGND VGND VPWR VPWR cn\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1630_ _0721_ _0725_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__nand2_1
XFILLER_31_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1561_ _0950_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__xnor2_1
X_1492_ _0870_ _0885_ _0884_ _0845_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__o211a_1
XFILLER_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2113_ _0447_ _0451_ net201 VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__mux2_1
X_2044_ _0395_ _0396_ net253 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__mux2_1
X_1828_ _0732_ _0734_ _0218_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__nor3_1
X_1759_ _0848_ _0157_ _0156_ _0155_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_1_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1544_ _0895_ _0914_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__nor2_2
X_1613_ net153 net28 net220 VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__mux2_1
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
X_1475_ _0866_ _0868_ _0859_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a21o_1
Xfanout208 net209 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__clkbuf_4
Xfanout219 net221 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__buf_4
XFILLER_54_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2027_ cn\[26\] _0382_ net223 VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__mux2_1
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1260_ net14 net235 net233 VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__or3_2
Xinput8 des_data[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_1191_ cn\[11\] _0588_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_34_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1527_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__inv_2
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1458_ cn\[15\] _0849_ _0850_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__or3_2
XFILLER_27_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1389_ _0778_ _0783_ _0763_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__mux2_1
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1312_ net237 net230 net143 VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__a21o_1
XFILLER_56_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2292_ clknet_4_15_0_clk _0076_ VGND VGND VPWR VPWR cn_dn\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1243_ _0635_ _0636_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__xor2_1
X_1174_ _0557_ _0561_ _0562_ _0569_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__a221o_1
XFILLER_32_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput164 net164 VGND VGND VPWR VPWR desc_result[45] sky130_fd_sc_hd__buf_4
Xoutput153 net153 VGND VGND VPWR VPWR desc_result[35] sky130_fd_sc_hd__buf_4
Xoutput186 net186 VGND VGND VPWR VPWR desc_result[7] sky130_fd_sc_hd__buf_4
Xoutput131 net131 VGND VGND VPWR VPWR desc_result[15] sky130_fd_sc_hd__buf_4
Xoutput142 net142 VGND VGND VPWR VPWR desc_result[25] sky130_fd_sc_hd__buf_4
Xoutput175 net175 VGND VGND VPWR VPWR desc_result[55] sky130_fd_sc_hd__buf_4
XFILLER_55_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1930_ cn\[6\] _0305_ net224 VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__mux2_1
Xinput55 des_data[59] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput11 des_data[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
Xinput22 des_data[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
Xinput77 des_key_in[20] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_1
Xinput66 des_encipher_en VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
Xinput88 des_key_in[31] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
X_1861_ _0248_ _0250_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__o21ai_1
Xinput33 des_data[39] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput44 des_data[49] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
X_1792_ _0551_ _0571_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__nor2_1
Xinput99 des_key_in[43] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
XFILLER_37_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1226_ _0601_ _0602_ _0594_ _0596_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__o211a_1
X_1157_ _0555_ _0556_ _0531_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__a21o_1
X_2275_ clknet_4_1_0_clk _0059_ VGND VGND VPWR VPWR cn\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2060_ cn_dn\[4\] _0409_ net226 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__mux2_1
X_1913_ _0287_ _0291_ net199 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__mux2_1
XFILLER_34_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1844_ _0937_ _0230_ _0233_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__o31a_1
X_1775_ net169 _0172_ net239 VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__mux2_1
XFILLER_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2258_ clknet_4_6_0_clk _0042_ VGND VGND VPWR VPWR cn\[2\] sky130_fd_sc_hd__dfxtp_1
X_2327_ clknet_4_9_0_clk _0111_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dfxtp_1
X_2189_ net135 net247 VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__and2_1
XFILLER_25_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1209_ cn\[27\] _0605_ _0606_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__nor3_1
XFILLER_48_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1560_ _0656_ _0663_ _0649_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__a21o_1
X_2112_ cn_dn\[17\] net74 net206 VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__mux2_1
X_1491_ _0868_ _0880_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__and2b_1
X_2043_ _0389_ _0394_ net200 VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__mux2_1
X_1827_ _0726_ _0218_ _0713_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a21o_1
XFILLER_13_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1758_ _0859_ _0870_ _0878_ _0884_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__o31ai_1
X_1689_ _0804_ _0813_ net191 VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout209 _0271_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__clkbuf_4
X_1543_ _0916_ _0927_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__and3_1
X_1474_ _0857_ _0858_ _0852_ _0853_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__o211a_1
XFILLER_5_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1612_ _0831_ _0992_ _0993_ _0998_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__o41a_1
XFILLER_54_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2026_ _0380_ _0381_ net249 VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__mux2_1
XFILLER_49_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput9 des_data[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_1190_ cn\[11\] _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__xor2_2
XFILLER_36_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1457_ _0849_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__nor2_2
X_1526_ _0900_ _0911_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__nand2_2
X_1388_ _0767_ net192 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__xnor2_2
X_2009_ _0366_ _0368_ net249 VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__mux2_1
XFILLER_58_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_31_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1311_ cn_dn\[8\] _0527_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__xnor2_2
X_2291_ clknet_4_15_0_clk _0075_ VGND VGND VPWR VPWR cn_dn\[7\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1242_ _0585_ _0639_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__and3_1
X_1173_ _0530_ _0554_ _0570_ _0572_ _0523_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__o311a_1
XFILLER_20_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput143 net143 VGND VGND VPWR VPWR desc_result[26] sky130_fd_sc_hd__buf_4
Xoutput132 net132 VGND VGND VPWR VPWR desc_result[16] sky130_fd_sc_hd__buf_4
Xoutput165 net165 VGND VGND VPWR VPWR desc_result[46] sky130_fd_sc_hd__buf_4
X_1509_ cn_dn\[9\] _0709_ _0710_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__and3b_1
Xoutput154 net154 VGND VGND VPWR VPWR desc_result[36] sky130_fd_sc_hd__buf_4
Xoutput176 net176 VGND VGND VPWR VPWR desc_result[56] sky130_fd_sc_hd__buf_4
Xoutput187 net187 VGND VGND VPWR VPWR desc_result[8] sky130_fd_sc_hd__buf_4
XFILLER_15_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_26_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1860_ net131 net6 net217 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__mux2_1
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput12 des_data[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
Xinput78 des_key_in[21] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
Xinput67 des_key_in[10] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
Xinput89 des_key_in[33] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_1
Xinput34 des_data[3] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput23 des_data[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput45 des_data[4] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput56 des_data[5] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
X_1791_ _0549_ _0551_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__or2_1
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2343_ clknet_4_8_0_clk _0127_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dfxtp_1
X_2274_ clknet_4_1_0_clk _0058_ VGND VGND VPWR VPWR cn\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1225_ _0598_ _0613_ _0590_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a21oi_1
X_1156_ _0544_ _0551_ _0549_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a21o_1
XFILLER_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1989_ _0350_ _0352_ net248 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__mux2_1
XFILLER_28_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1912_ cn\[5\] net109 net205 VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__mux2_1
X_1843_ _0900_ _0904_ _0923_ _0234_ _0938_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__a221o_1
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1774_ _0170_ _0171_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__xor2_1
XFILLER_8_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2257_ clknet_4_6_0_clk _0041_ VGND VGND VPWR VPWR cn\[1\] sky130_fd_sc_hd__dfxtp_1
X_1208_ _0605_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nor2_2
X_2326_ clknet_4_2_0_clk _0110_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dfxtp_1
X_2188_ net144 _0711_ net244 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__mux2_1
X_1139_ net9 net234 net232 VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__or3_2
XFILLER_4_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1490_ _0854_ _0873_ _0871_ _0867_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a211o_1
X_2111_ _0435_ _0439_ net214 VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__mux2_1
X_2042_ _0387_ _0393_ net215 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1826_ net194 _0728_ _0732_ _0735_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_29_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1757_ _0846_ _0152_ _0153_ _0882_ _0848_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a221o_1
X_1688_ _1068_ _1069_ _1070_ _1067_ _0799_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_13_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2309_ clknet_4_14_0_clk _0093_ VGND VGND VPWR VPWR cn_dn\[25\] sky130_fd_sc_hd__dfxtp_4
XTAP_TAPCELL_ROW_0_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1611_ _0817_ _0819_ _0826_ _0834_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a221o_1
X_1542_ _0922_ _0930_ _0911_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__a21o_1
X_1473_ _0857_ _0858_ _0862_ _0864_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__o22a_1
XFILLER_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2025_ _0272_ _0281_ net197 VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__mux2_1
XFILLER_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1809_ _0680_ _0201_ _0202_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__o31ai_1
XFILLER_49_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1456_ net58 net237 net230 VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__and3b_1
X_1525_ _0908_ _0912_ _0917_ _0906_ _0914_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__o221a_1
X_1387_ _0768_ net192 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__xnor2_1
X_2008_ _0363_ _0367_ net196 VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__mux2_1
XFILLER_23_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_47_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2290_ clknet_4_14_0_clk _0074_ VGND VGND VPWR VPWR cn_dn\[6\] sky130_fd_sc_hd__dfxtp_4
X_1310_ net159 _0707_ net242 VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__mux2_1
X_1241_ _0623_ _0635_ _0638_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_56_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1172_ _0565_ _0571_ _0543_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__mux2_1
XFILLER_17_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput144 net144 VGND VGND VPWR VPWR desc_result[27] sky130_fd_sc_hd__buf_4
Xoutput166 net166 VGND VGND VPWR VPWR desc_result[47] sky130_fd_sc_hd__buf_4
Xoutput133 net133 VGND VGND VPWR VPWR desc_result[17] sky130_fd_sc_hd__buf_4
Xoutput177 net177 VGND VGND VPWR VPWR desc_result[57] sky130_fd_sc_hd__buf_4
Xoutput155 net155 VGND VGND VPWR VPWR desc_result[37] sky130_fd_sc_hd__buf_4
XFILLER_55_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1508_ _0898_ _0899_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nor2_2
X_1439_ _0803_ _0812_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nand2_1
Xoutput188 net188 VGND VGND VPWR VPWR desc_result[9] sky130_fd_sc_hd__buf_4
XFILLER_46_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput13 des_data[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
X_1790_ net183 _0186_ net241 VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__mux2_1
XFILLER_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput46 des_data[50] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput57 des_data[60] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput68 des_key_in[11] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_1
Xinput79 des_key_in[22] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_1
Xinput24 des_data[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput35 des_data[40] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
XFILLER_37_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2342_ clknet_4_2_0_clk _0126_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dfxtp_1
X_1224_ _0597_ _0612_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nor2_1
X_2273_ clknet_4_1_0_clk _0057_ VGND VGND VPWR VPWR cn\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1155_ _0543_ _0550_ _0551_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or3b_2
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1988_ _0347_ _0351_ net196 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__mux2_1
XFILLER_43_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_28_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout190 _0807_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_2
XFILLER_21_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1911_ _0277_ _0278_ net212 VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__mux2_1
X_1842_ _0915_ _0919_ _0922_ _0907_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__a31o_1
X_1773_ net180 net45 net217 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__mux2_1
X_2325_ clknet_4_13_0_clk _0109_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dfxtp_1
XFILLER_57_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2256_ clknet_4_6_0_clk _0040_ VGND VGND VPWR VPWR cn\[0\] sky130_fd_sc_hd__dfxtp_2
X_1207_ net25 net236 net229 VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__and3b_1
X_2187_ net153 _0714_ net243 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__mux2_1
XFILLER_40_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1138_ net236 net229 net132 VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_3_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2110_ cn_dn\[14\] _0449_ net226 VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__mux2_1
X_2041_ cn_dn\[3\] net92 net208 VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_17_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1825_ net194 _0728_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__nor2_1
X_1756_ _0845_ _0154_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__and2_1
X_1687_ net191 _0804_ net190 VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__or3_1
X_2308_ clknet_4_10_0_clk _0092_ VGND VGND VPWR VPWR cn_dn\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2239_ clknet_4_7_0_clk _0025_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1610_ _0800_ _0817_ _0831_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__o21ai_1
X_1541_ _0895_ _0918_ _0925_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a2bb2o_1
X_1472_ _0863_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__nand2_1
XFILLER_5_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2024_ _0367_ _0371_ net211 VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__mux2_1
XFILLER_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1739_ _0733_ _0747_ _0750_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__and3_1
X_1808_ _0201_ _0202_ _0680_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__o21ai_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1524_ _0904_ _0910_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__xnor2_4
X_1455_ net237 net230 net181 VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__a21oi_2
X_1386_ _0767_ _0780_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__nand2_1
XFILLER_35_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2007_ cn\[24\] net88 net203 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__mux2_1
XFILLER_50_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_56_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1171_ _0528_ _0529_ _0547_ _0548_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a211o_1
X_1240_ _0623_ _0635_ _0638_ _0581_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_47_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput178 net178 VGND VGND VPWR VPWR desc_result[58] sky130_fd_sc_hd__buf_4
Xoutput134 net134 VGND VGND VPWR VPWR desc_result[18] sky130_fd_sc_hd__buf_4
X_1507_ _0898_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__or2_2
Xoutput156 net156 VGND VGND VPWR VPWR desc_result[38] sky130_fd_sc_hd__buf_4
Xoutput145 net145 VGND VGND VPWR VPWR desc_result[28] sky130_fd_sc_hd__buf_4
Xoutput167 net167 VGND VGND VPWR VPWR desc_result[48] sky130_fd_sc_hd__buf_4
X_1369_ cn\[7\] _0681_ _0682_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__and3b_2
X_1438_ _0821_ _0829_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_53_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput14 des_data[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput36 des_data[41] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput25 des_data[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
XFILLER_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput58 des_data[61] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput47 des_data[51] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
Xinput69 des_key_in[12] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_1
X_2341_ clknet_4_2_0_clk _0125_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dfxtp_1
X_2272_ clknet_4_1_0_clk _0056_ VGND VGND VPWR VPWR cn\[16\] sky130_fd_sc_hd__dfxtp_1
X_1223_ _0597_ _0617_ _0620_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__o21a_1
X_1154_ _0544_ _0549_ _0551_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__and3_1
XFILLER_60_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1987_ cn\[20\] net119 net204 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__mux2_1
XFILLER_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout191 _0801_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_2
X_1910_ cn\[2\] _0289_ net224 VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__mux2_1
X_1841_ _0935_ _0180_ _0231_ _0232_ _0913_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__a32o_1
XFILLER_6_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1772_ _0627_ _0164_ _0167_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o31a_1
X_2324_ clknet_4_13_0_clk _0108_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dfxtp_1
XFILLER_6_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2255_ clknet_4_5_0_clk _0039_ net123 VGND VGND VPWR VPWR rcounter\[3\] sky130_fd_sc_hd__dfrtp_1
X_2186_ net162 _0727_ net244 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__mux2_1
XFILLER_25_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1206_ net236 net229 net148 VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a21oi_2
X_1137_ _0535_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__nor2_1
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2040_ cn_dn\[0\] net116 net208 VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__mux2_1
XFILLER_30_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1824_ _0739_ _0747_ _0750_ _0216_ _0708_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__a221o_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
X_1755_ _0870_ _0875_ _0888_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o21ai_1
X_1686_ _0804_ net190 _0814_ _0801_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__o211ai_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2307_ clknet_4_12_0_clk _0091_ VGND VGND VPWR VPWR cn_dn\[23\] sky130_fd_sc_hd__dfxtp_1
X_2238_ clknet_4_0_0_clk _0024_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2169_ _0393_ _0390_ net202 VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1540_ _0908_ _0929_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__xor2_1
XFILLER_5_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1471_ _0860_ _0861_ cn\[8\] VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a21bo_1
XFILLER_5_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2023_ cn\[25\] _0379_ net223 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__mux2_1
X_1807_ net195 _0694_ _1060_ _0684_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_20_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1738_ _0742_ _1014_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__xnor2_1
X_1669_ _1052_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__xnor2_1
XFILLER_5_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1523_ _0905_ _0911_ _0906_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__a21oi_1
X_1454_ _0845_ _0846_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__and2_1
X_1385_ cn\[13\] _0779_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__xnor2_4
XFILLER_50_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2006_ _0351_ _0355_ net211 VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__mux2_1
XFILLER_2_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1170_ _0542_ _0549_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__nor2_1
XFILLER_2_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput179 net179 VGND VGND VPWR VPWR desc_result[59] sky130_fd_sc_hd__buf_4
Xoutput135 net135 VGND VGND VPWR VPWR desc_result[19] sky130_fd_sc_hd__buf_4
Xoutput124 net124 VGND VGND VPWR VPWR desc_ready sky130_fd_sc_hd__buf_4
X_1506_ _0896_ _0897_ cn_dn\[19\] VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__a21boi_2
Xoutput168 net168 VGND VGND VPWR VPWR desc_result[49] sky130_fd_sc_hd__buf_4
Xoutput157 net157 VGND VGND VPWR VPWR desc_result[39] sky130_fd_sc_hd__buf_4
X_1437_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__inv_2
Xoutput146 net146 VGND VGND VPWR VPWR desc_result[29] sky130_fd_sc_hd__buf_4
X_1299_ _0656_ _0672_ _0674_ _0649_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__o211a_1
X_1368_ cn\[0\] _0579_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_53_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput59 des_data[62] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
XFILLER_52_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput26 des_data[32] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
Xinput37 des_data[42] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput48 des_data[52] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput15 des_data[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2271_ clknet_4_1_0_clk _0055_ VGND VGND VPWR VPWR cn\[15\] sky130_fd_sc_hd__dfxtp_1
X_2340_ clknet_4_2_0_clk _0124_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dfxtp_1
X_1222_ _0597_ _0604_ _0589_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a21o_1
X_1153_ _0544_ _0551_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1986_ _0335_ _0339_ net210 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__mux2_1
XFILLER_11_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout192 _0780_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_4
X_1840_ _0907_ _0919_ _0922_ _0928_ _0228_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__a32o_1
XFILLER_6_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1771_ _0614_ _0960_ _0168_ _0627_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__o211ai_1
X_2254_ clknet_4_5_0_clk _0038_ net123 VGND VGND VPWR VPWR rcounter\[2\] sky130_fd_sc_hd__dfrtp_1
X_2323_ clknet_4_10_0_clk _0107_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dfxtp_1
X_2185_ net245 _0717_ _0718_ _0501_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a31o_1
XFILLER_25_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1205_ _0601_ _0602_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__nor2_2
X_1136_ _0532_ _0533_ cn_dn\[22\] VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__a21oi_2
XFILLER_33_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1969_ _0334_ _0336_ net248 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__mux2_1
XFILLER_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1823_ _0722_ _0729_ _0715_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a21oi_1
XFILLER_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1754_ _0883_ _0889_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__xor2_1
X_1685_ _0828_ _0836_ _0988_ _0996_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a22o_1
X_2237_ clknet_4_7_0_clk _0023_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dfxtp_1
X_2306_ clknet_4_11_0_clk _0090_ VGND VGND VPWR VPWR cn_dn\[22\] sky130_fd_sc_hd__dfxtp_1
X_1119_ net238 net231 net178 VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a21o_1
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2099_ _0438_ _0440_ net254 VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__mux2_1
X_2168_ _0483_ _0386_ net213 VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1470_ _0860_ _0861_ cn\[8\] VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2022_ _0377_ _0378_ net249 VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__mux2_1
X_1806_ _0694_ _1060_ net195 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_17_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1668_ net158 net23 net219 VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__mux2_1
X_1599_ net191 _0803_ _0812_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__or3_1
X_1737_ net145 _0137_ net240 VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__mux2_1
XFILLER_45_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_59_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1522_ _0904_ _0910_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__nand2_1
X_1453_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__inv_2
XFILLER_35_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2005_ cn\[21\] _0365_ net222 VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__mux2_1
X_1384_ cn\[13\] _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__xor2_2
XFILLER_50_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput125 net125 VGND VGND VPWR VPWR desc_result[0] sky130_fd_sc_hd__buf_4
Xoutput136 net136 VGND VGND VPWR VPWR desc_result[1] sky130_fd_sc_hd__buf_4
X_1505_ cn_dn\[19\] _0896_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__and3b_1
Xoutput158 net158 VGND VGND VPWR VPWR desc_result[3] sky130_fd_sc_hd__buf_4
Xoutput147 net147 VGND VGND VPWR VPWR desc_result[2] sky130_fd_sc_hd__buf_4
Xoutput169 net169 VGND VGND VPWR VPWR desc_result[4] sky130_fd_sc_hd__buf_4
X_1436_ _0797_ _0799_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__and2_2
X_1367_ cn\[0\] _0579_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__xor2_4
XFILLER_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1298_ net195 _0691_ _0695_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_43_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput27 des_data[33] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput16 des_data[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput49 des_data[53] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
Xinput38 des_data[43] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
XFILLER_35_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2270_ clknet_4_1_0_clk _0054_ VGND VGND VPWR VPWR cn\[14\] sky130_fd_sc_hd__dfxtp_2
X_1221_ _0597_ _0604_ _0589_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a21oi_1
X_1152_ _0549_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1985_ cn\[17\] _0349_ net222 VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__mux2_1
XFILLER_9_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1419_ _0805_ _0806_ _0810_ _0811_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_28_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_5_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout193 _0764_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__buf_2
XFILLER_19_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1770_ _0597_ _0617_ _0623_ _0590_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a211o_1
X_2253_ clknet_4_5_0_clk _0037_ net123 VGND VGND VPWR VPWR rcounter\[1\] sky130_fd_sc_hd__dfrtp_2
X_2184_ net171 _0509_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__and2_1
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2322_ clknet_4_14_0_clk _0106_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dfxtp_1
X_1204_ _0601_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__or2_1
XFILLER_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1135_ cn_dn\[22\] _0532_ _0533_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__and3_2
X_1899_ cn\[0\] _0280_ net224 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__mux2_1
X_1968_ _0331_ _0335_ net196 VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__mux2_1
XFILLER_56_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1753_ _0883_ _0889_ _0151_ _0871_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1822_ net156 _0215_ net243 VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__mux2_1
X_1684_ _0826_ _0835_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__xnor2_1
X_2236_ clknet_4_13_0_clk _0022_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dfxtp_1
X_2167_ cn_dn\[26\] _0494_ net226 VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__mux2_1
X_2305_ clknet_4_8_0_clk _0089_ VGND VGND VPWR VPWR cn_dn\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2098_ _0435_ _0439_ net201 VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__mux2_1
X_1118_ cn_dn\[3\] _0516_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__xnor2_2
XFILLER_48_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2021_ _0273_ _0272_ net197 VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__mux2_1
X_1805_ _0198_ _0199_ _0698_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__o21ba_1
X_1736_ _0135_ _0136_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__xnor2_1
X_1598_ net161 _0987_ net245 VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__mux2_1
X_1667_ _1048_ _1050_ _1051_ _1045_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__a31o_1
XFILLER_53_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2219_ clknet_4_10_0_clk _0005_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1383_ net165 net42 net218 VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__mux2_4
X_1521_ cn_dn\[1\] _0714_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__xnor2_2
X_1452_ cn\[12\] _0667_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__xor2_4
XFILLER_35_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2004_ _0362_ _0364_ net249 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__mux2_1
XFILLER_50_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1719_ _0773_ _0783_ _1092_ _0764_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__o211a_1
XFILLER_58_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput137 net137 VGND VGND VPWR VPWR desc_result[20] sky130_fd_sc_hd__buf_4
X_1504_ net11 net235 net233 VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__or3_2
Xoutput159 net159 VGND VGND VPWR VPWR desc_result[40] sky130_fd_sc_hd__buf_4
Xoutput148 net148 VGND VGND VPWR VPWR desc_result[30] sky130_fd_sc_hd__buf_4
Xoutput126 net126 VGND VGND VPWR VPWR desc_result[10] sky130_fd_sc_hd__buf_4
XFILLER_55_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1435_ _0824_ _0825_ _0827_ _0821_ _0797_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a32o_1
X_1366_ _0756_ _0758_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1297_ _0688_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand2_1
XFILLER_23_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput39 des_data[44] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XFILLER_52_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput28 des_data[34] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
Xinput17 des_data[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
XFILLER_28_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1220_ _0598_ _0603_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_9_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1151_ _0535_ _0536_ _0540_ _0541_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__or4_4
XFILLER_60_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1984_ _0346_ _0348_ net248 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__mux2_1
X_1349_ _0723_ _0724_ _0728_ _0731_ _0716_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__o311a_1
X_1418_ _0810_ _0811_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__or2_1
XFILLER_11_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout194 _0716_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2321_ clknet_4_15_0_clk _0105_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dfxtp_1
X_2183_ net179 _0521_ net245 VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__mux2_1
X_2252_ clknet_4_5_0_clk _0036_ net123 VGND VGND VPWR VPWR rcounter\[0\] sky130_fd_sc_hd__dfrtp_4
X_1203_ _0599_ _0600_ cn\[4\] VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a21boi_2
X_1134_ _0532_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__and2_1
X_1898_ _0274_ _0279_ net249 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__mux2_1
X_1967_ cn\[16\] net87 net203 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__mux2_1
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1683_ net181 _1066_ net241 VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__mux2_1
X_1752_ _0866_ _0868_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1821_ _0213_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__xnor2_1
X_2304_ clknet_4_9_0_clk _0088_ VGND VGND VPWR VPWR cn_dn\[20\] sky130_fd_sc_hd__dfxtp_1
X_2097_ cn_dn\[14\] net98 net206 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__mux2_1
X_1117_ cn_dn\[3\] _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__xor2_1
X_2166_ _0492_ _0493_ net253 VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2235_ clknet_4_3_0_clk _0021_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2020_ _0363_ _0367_ net211 VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__mux2_1
X_1804_ _0648_ _0700_ _0951_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__and3_1
X_1666_ _0636_ _0958_ _0959_ _0626_ _0580_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__o221ai_1
X_1735_ net146 net21 net218 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__mux2_1
X_1597_ _0985_ _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__xor2_1
X_2218_ clknet_4_15_0_clk _0004_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2149_ _0478_ _0480_ net252 VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__mux2_1
XFILLER_14_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1520_ cn_dn\[1\] _0714_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__xor2_1
X_1451_ cn\[26\] _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__xor2_2
X_1382_ _0775_ _0776_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__or2_1
XFILLER_35_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2003_ _0359_ _0363_ net197 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__mux2_1
X_1718_ _1097_ _1098_ _0760_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__o21a_1
X_1649_ net193 _0768_ _0773_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_56_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput138 net138 VGND VGND VPWR VPWR desc_result[21] sky130_fd_sc_hd__buf_4
X_1503_ net237 net230 net134 VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__a21o_1
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput149 net149 VGND VGND VPWR VPWR desc_result[31] sky130_fd_sc_hd__buf_4
Xoutput127 net127 VGND VGND VPWR VPWR desc_result[11] sky130_fd_sc_hd__buf_4
X_1296_ _0668_ _0669_ _0653_ _0654_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__o211ai_2
X_1434_ _0797_ _0799_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__or2_1
X_1365_ _0756_ _0758_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__and2_1
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput18 des_data[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
Xinput29 des_data[35] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_9_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1150_ _0547_ _0548_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nor2_1
X_1983_ _0343_ _0347_ net196 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__mux2_1
X_1417_ _0810_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__nor2_2
X_1348_ _0715_ _0730_ _0735_ _0739_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__o211a_1
X_1279_ _0675_ _0676_ _0649_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__a21o_1
Xfanout195 _0648_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2320_ clknet_4_13_0_clk _0104_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dfxtp_1
X_2251_ clknet_4_5_0_clk _0035_ net123 VGND VGND VPWR VPWR key_process sky130_fd_sc_hd__dfrtp_2
X_2182_ net136 _0527_ net245 VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__mux2_1
X_1202_ cn\[4\] _0599_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__and3b_1
X_1133_ net18 net234 net232 VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__or3_1
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
X_1966_ _0319_ _0323_ net210 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__mux2_1
X_1897_ _0277_ _0278_ net198 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__mux2_1
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1820_ net157 net32 net220 VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__mux2_1
X_1751_ net129 net4 net218 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__mux2_1
X_1682_ _1064_ _1065_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__xor2_1
X_2303_ clknet_4_12_0_clk _0087_ VGND VGND VPWR VPWR cn_dn\[19\] sky130_fd_sc_hd__dfxtp_1
X_2234_ clknet_4_0_0_clk _0020_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dfxtp_1
X_1116_ net150 net27 net221 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__mux2_4
X_2096_ _0423_ _0427_ net215 VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__mux2_1
X_2165_ _0387_ _0393_ net202 VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1949_ _0318_ _0320_ net250 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__mux2_1
XFILLER_21_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _0649_ _0675_ _0676_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1596_ net162 net37 net220 VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__mux2_1
X_1734_ _0132_ _0134_ _0524_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__mux2_1
X_1665_ _0586_ _0963_ _1049_ _0628_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__o31a_1
XFILLER_38_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2217_ clknet_4_9_0_clk _0003_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dfxtp_1
X_2079_ _0422_ _0424_ net255 VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__mux2_1
XFILLER_26_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2148_ _0475_ _0479_ net200 VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1450_ net147 net34 net219 VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux2_4
X_1381_ _0775_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nor2_1
XFILLER_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2002_ cn\[23\] net95 net203 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__mux2_1
XFILLER_23_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1717_ _0784_ _1096_ _0758_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__a21o_1
X_1648_ _0768_ _0773_ net193 VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__a21oi_2
X_1579_ _0616_ _0620_ _0632_ _0626_ _0587_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__a311o_1
XFILLER_58_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput128 net128 VGND VGND VPWR VPWR desc_result[12] sky130_fd_sc_hd__buf_4
XFILLER_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1502_ cn_dn\[15\] _0851_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__xnor2_1
Xoutput139 net139 VGND VGND VPWR VPWR desc_result[22] sky130_fd_sc_hd__buf_4
X_1433_ _0797_ _0799_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__nor2_1
X_1295_ _0689_ _0690_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nor3_1
X_1364_ _0756_ _0758_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__or2_1
XFILLER_23_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 des_data[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_52_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1982_ cn\[19\] net120 net203 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__mux2_1
XFILLER_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1347_ _0708_ _0712_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__nand2b_1
X_1416_ cn_dn\[20\] _0808_ _0809_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__and3_1
X_1278_ _0655_ _0672_ _0674_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__nand3_1
XFILLER_43_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout196 net199 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_6_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2250_ clknet_4_5_0_clk _0034_ net123 VGND VGND VPWR VPWR encipher_process sky130_fd_sc_hd__dfrtp_4
X_1201_ net16 net234 net232 VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__or3_1
X_2181_ net242 _0545_ _0546_ _0500_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__a31o_1
X_1132_ net236 net229 net141 VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__a21o_1
X_1965_ cn\[13\] _0333_ net222 VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__mux2_1
X_1896_ cn\[2\] net69 net209 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_3_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1750_ net137 _0149_ net244 VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__mux2_1
XFILLER_30_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1681_ net182 net57 net218 VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__mux2_1
XFILLER_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2233_ clknet_4_7_0_clk _0019_ VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dfxtp_1
X_2302_ clknet_4_12_0_clk _0086_ VGND VGND VPWR VPWR cn_dn\[18\] sky130_fd_sc_hd__dfxtp_1
X_2164_ _0479_ _0483_ net215 VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__mux2_1
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2095_ cn_dn\[11\] _0437_ net226 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__mux2_1
X_1115_ net234 net232 VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1879_ rcounter\[0\] key_process VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__nand2_1
X_1948_ _0315_ _0319_ net198 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__mux2_1
XFILLER_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_22_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1733_ _0563_ _0130_ _0131_ _0133_ _0129_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__o311a_1
X_1802_ net174 _0197_ net239 VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__mux2_1
X_1595_ _0975_ _0982_ _0984_ _0524_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__o22a_1
X_1664_ _0621_ _0623_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__nor2_1
XFILLER_53_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2216_ clknet_4_8_0_clk _0002_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dfxtp_1
X_2147_ cn_dn\[24\] net81 net208 VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__mux2_1
X_2078_ _0419_ _0423_ net202 VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__mux2_1
XFILLER_41_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1380_ _0765_ _0766_ _0771_ _0772_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o22a_2
X_2001_ _0347_ _0351_ net211 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__mux2_1
XFILLER_50_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1716_ _0784_ _1096_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__nor2_1
X_1647_ _0782_ _0786_ _0787_ _0758_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__a211o_1
X_1578_ _0581_ _0968_ _0586_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__a21o_1
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_38_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput129 net129 VGND VGND VPWR VPWR desc_result[13] sky130_fd_sc_hd__buf_4
X_1501_ cn_dn\[15\] _0851_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__xor2_2
X_1432_ _0804_ net190 _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__o21ai_1
X_1363_ _0756_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__nor2_1
XFILLER_48_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1294_ _0655_ _0663_ _0670_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__and3_1
XFILLER_31_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1981_ _0331_ _0335_ net210 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__mux2_1
X_1346_ _0715_ _0733_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__nor2_1
XFILLER_3_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1415_ _0808_ _0809_ cn_dn\[20\] VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__a21oi_2
XFILLER_51_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1277_ _0672_ _0674_ _0655_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__a21o_1
XFILLER_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout197 net199 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1200_ net236 net229 net139 VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a21o_1
XFILLER_2_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2180_ net188 net247 VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__and2_1
X_1131_ _0528_ _0529_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and2_2
XPHY_EDGE_ROW_25_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1895_ cn\[1\] net77 net205 VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__mux2_1
X_1964_ _0330_ _0332_ net248 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__mux2_1
X_1329_ _0719_ _0720_ _0723_ _0724_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__or4_4
XTAP_TAPCELL_ROW_3_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1680_ _0702_ _1056_ _1063_ _1062_ _1057_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__o32a_1
X_2301_ clknet_4_12_0_clk _0085_ VGND VGND VPWR VPWR cn_dn\[17\] sky130_fd_sc_hd__dfxtp_1
X_1114_ rcounter\[0\] encipher_process VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__xnor2_1
XFILLER_38_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2163_ cn_dn\[25\] _0491_ net225 VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__mux2_1
X_2232_ clknet_4_0_0_clk _0018_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2094_ _0434_ _0436_ net254 VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1878_ key_process _0261_ _0000_ net65 net66 VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__a2111o_1
X_1947_ cn\[12\] net118 net205 VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__mux2_1
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1663_ _0587_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__or2_1
X_1801_ _0195_ _0196_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__xnor2_1
X_1732_ _0531_ _0552_ _0558_ _0567_ _0976_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__a311o_1
X_1594_ _0566_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2077_ cn_dn\[10\] net68 net207 VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2215_ clknet_4_9_0_clk _0001_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dfxtp_1
X_2146_ _0463_ _0467_ net213 VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__mux2_1
XFILLER_14_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2000_ cn\[20\] _0361_ net223 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__mux2_1
XFILLER_50_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1646_ net193 _1027_ _1031_ _0761_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__o211ai_1
X_1715_ _0763_ _0773_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nand2_1
X_1577_ _0636_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__xnor2_1
X_2129_ _0462_ _0464_ net252 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__mux2_1
XFILLER_57_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1500_ net187 _0893_ net243 VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__mux2_1
X_1293_ _0655_ _0663_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nand2_1
X_1431_ _0804_ net190 net191 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__a21oi_2
X_1362_ cn\[25\] _0607_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__xnor2_2
XFILLER_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1629_ net194 _1014_ _1015_ _0713_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__a211o_1
XFILLER_54_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1980_ cn\[16\] _0345_ net223 VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__mux2_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1276_ _0668_ _0669_ _0660_ _0662_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__o211ai_4
X_1345_ net194 _0726_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__nand2_1
X_1414_ net44 net234 net232 VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__or3_1
XFILLER_51_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_4
XFILLER_10_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1130_ _0528_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_0_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1894_ _0260_ _0263_ _0264_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__o21a_1
X_1963_ _0327_ _0331_ net196 VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__mux2_1
X_1259_ net237 net230 net137 VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__a21o_1
X_1328_ _0723_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_3_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2231_ clknet_4_7_0_clk _0017_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dfxtp_1
X_2300_ clknet_4_12_0_clk _0084_ VGND VGND VPWR VPWR cn_dn\[16\] sky130_fd_sc_hd__dfxtp_2
XFILLER_53_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1113_ rcounter\[0\] encipher_process VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__xor2_2
X_2093_ _0431_ _0435_ net202 VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__mux2_1
X_2162_ _0489_ _0490_ net253 VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1877_ encipher_process _0264_ encipher_en_sync VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__a21o_1
X_1946_ _0303_ _0307_ net216 VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__mux2_1
XFILLER_0_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1800_ net175 net50 net217 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__mux2_1
X_1662_ _0614_ _0960_ _1046_ _0590_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__o22a_1
X_1731_ _0530_ _0555_ _0558_ _0560_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a31o_1
X_1593_ _0542_ _0549_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__xnor2_1
X_2214_ net186 _0588_ net242 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__mux2_1
X_2076_ _0407_ _0411_ net214 VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__mux2_1
XFILLER_38_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2145_ cn_dn\[21\] _0477_ net225 VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__mux2_1
X_1929_ _0302_ _0304_ net250 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__mux2_1
XFILLER_39_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1645_ _0763_ _1029_ _1030_ _1028_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__o22a_1
X_1576_ _0616_ _0630_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nand2_1
X_1714_ _1094_ _1036_ _1093_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__or3b_1
XFILLER_58_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2059_ _0406_ _0408_ net253 VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__mux2_1
XFILLER_34_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2128_ _0459_ _0463_ net200 VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__mux2_1
XFILLER_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1430_ _0797_ _0798_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__nor2_1
X_1292_ _0680_ _0684_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__or2_1
XFILLER_0_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1361_ cn\[25\] _0607_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__xor2_1
X_1628_ _0735_ _1013_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21oi_1
X_1559_ _0656_ _0663_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__nand2_1
XFILLER_39_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1413_ net236 net229 net167 VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__a21o_1
XFILLER_3_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1275_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__inv_2
X_1344_ _0708_ _0712_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__or2_2
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout199 _0276_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ cn\[15\] net94 net204 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__mux2_1
X_1893_ net250 key_process VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__or2_1
XFILLER_56_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1327_ _0519_ _0520_ cn_dn\[23\] VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a21oi_4
X_1258_ _0653_ _0654_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_3_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1189_ net185 net62 net219 VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__mux2_8
XFILLER_33_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2230_ clknet_4_9_0_clk _0016_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dfxtp_1
X_1112_ rcounter\[2\] rcounter\[3\] rcounter\[1\] VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__or3_1
X_2092_ cn_dn\[13\] net106 net207 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__mux2_1
XFILLER_38_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2161_ _0386_ _0387_ net200 VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1945_ cn\[9\] _0317_ net224 VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__mux2_1
XFILLER_9_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1876_ rcounter\[0\] net235 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__or2_1
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1592_ _0517_ _0981_ _0979_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__a21bo_1
X_1730_ _0531_ _0983_ _0553_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__o21a_1
X_1661_ _0604_ _0632_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2144_ _0474_ _0476_ net252 VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__mux2_1
X_2213_ net239 _0591_ _0592_ _0508_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_46_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2075_ cn_dn\[7\] _0421_ net227 VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__mux2_1
XFILLER_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1928_ _0299_ _0303_ net198 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__mux2_1
X_1859_ net193 _1027_ _0249_ _0760_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a211oi_1
XPHY_EDGE_ROW_55_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1713_ _0773_ _0783_ _1034_ _1092_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__o211a_1
XFILLER_6_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1644_ net193 _0773_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__nand2_1
X_1575_ _0963_ _0964_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__or3_1
X_2127_ cn_dn\[20\] net112 net208 VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__mux2_1
X_2058_ _0403_ _0407_ net201 VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__mux2_1
XFILLER_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1360_ cn\[18\] _0647_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__xnor2_4
X_1291_ _0664_ _0671_ _0688_ net195 VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__o211a_1
X_1558_ _0672_ _0674_ _0688_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__and3_1
X_1627_ _0725_ _0728_ _0730_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__a21o_1
X_1489_ _0867_ _0871_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_52_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1343_ _0708_ _0712_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nor2_1
XFILLER_3_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1412_ _0805_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand2_1
X_1274_ _0660_ _0662_ _0668_ _0669_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__a211o_2
XFILLER_51_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout189 _0907_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1892_ _0273_ _0272_ net211 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__mux2_1
X_1961_ _0315_ _0319_ net210 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__mux2_1
X_1326_ cn_dn\[23\] _0519_ _0520_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__and3_2
X_1257_ _0653_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__nand2_2
X_1188_ _0580_ _0585_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__or2_1
XFILLER_24_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2160_ _0475_ _0479_ net213 VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__mux2_1
X_1111_ rcounter\[2\] rcounter\[3\] rcounter\[1\] VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nor3_1
X_2091_ _0419_ _0423_ net214 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1875_ rcounter\[0\] rcounter\[3\] VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__nor2_1
X_1944_ _0314_ _0316_ net250 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__mux2_1
XFILLER_21_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_39_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2289_ clknet_4_14_0_clk _0073_ VGND VGND VPWR VPWR cn_dn\[5\] sky130_fd_sc_hd__dfxtp_4
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1309_ _0705_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__xor2_1
XFILLER_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1591_ _0530_ _0542_ _0571_ _0980_ _0523_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__a221o_1
XFILLER_7_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1660_ _0589_ _0635_ _0638_ _0618_ _0627_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__o221a_1
XFILLER_38_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2143_ _0470_ _0475_ net200 VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__mux2_1
X_2212_ net131 net247 VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__and2_1
X_2074_ _0418_ _0420_ net254 VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1927_ cn\[8\] net85 net205 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__mux2_1
X_1858_ _0773_ net192 _1034_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__o21a_1
X_1789_ _0173_ _0185_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__xor2_1
XFILLER_39_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_1 _0276_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1643_ _0775_ net192 VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nand2_1
X_1712_ _0774_ _0783_ _1034_ _1091_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__a211o_1
X_1574_ _0580_ _0586_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__nand2_1
X_2126_ _0447_ _0451_ net214 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__mux2_1
X_2057_ cn_dn\[6\] net99 net206 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__mux2_1
XFILLER_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1290_ _0653_ _0654_ _0668_ _0669_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__a211o_1
XFILLER_48_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1626_ _0722_ _0729_ net194 VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__a21o_1
X_1557_ _0677_ _0948_ _0690_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__a21o_1
X_1488_ _0845_ _0846_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__nor2_1
XFILLER_54_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2109_ _0446_ _0448_ net254 VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_52_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1273_ _0668_ _0669_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__nor2_1
X_1342_ _0721_ _0729_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__nand2_1
XFILLER_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1411_ _0582_ _0583_ cn_dn\[27\] VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__o21ai_1
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1609_ _0995_ _0996_ _0997_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__and3_1
XFILLER_42_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1960_ cn\[12\] _0329_ net224 VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__mux2_1
X_1891_ cn\[26\] net72 net204 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1256_ _0650_ _0651_ cn\[16\] VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__o21ai_2
X_1325_ _0719_ _0720_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__nor2_1
XFILLER_24_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1187_ cn\[14\] _0584_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__xnor2_2
XFILLER_59_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1110_ key_process encipher_process VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__nor2_1
X_2090_ cn_dn\[10\] _0433_ net226 VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__mux2_1
XFILLER_2_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1874_ net250 k16_calculation _0262_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__mux2_1
X_1943_ _0311_ _0315_ net198 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__mux2_1
XFILLER_9_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2288_ clknet_4_14_0_clk _0072_ VGND VGND VPWR VPWR cn_dn\[4\] sky130_fd_sc_hd__dfxtp_2
X_1308_ net160 net35 net217 VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__mux2_1
X_1239_ _0597_ _0604_ _0590_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a21o_1
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1590_ _0542_ _0559_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__and2b_1
X_2073_ _0415_ _0419_ net201 VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__mux2_1
XFILLER_38_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2142_ cn_dn\[23\] net89 net208 VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__mux2_1
X_2211_ net240 _0599_ _0600_ _0507_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__a31o_1
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1788_ _0181_ _0182_ _0183_ _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__o31a_1
X_1926_ _0287_ _0291_ net212 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__mux2_1
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1857_ _0242_ _0247_ _0760_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__o21a_1
XFILLER_29_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_2 _0509_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
X_1642_ _0767_ _0781_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__nor2_1
X_1711_ _0773_ _0781_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__nand2_1
X_1573_ _0618_ _0621_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nor2_1
XFILLER_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2125_ cn_dn\[17\] _0461_ net227 VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__mux2_1
X_2056_ _0389_ _0394_ net215 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__mux2_1
X_1909_ _0286_ _0288_ net251 VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__mux2_1
XFILLER_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_33_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1625_ net194 _0732_ _1010_ _0744_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__a31o_1
X_1556_ _0649_ _0674_ _0676_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__nand3_1
X_1487_ _0871_ _0875_ _0877_ _0879_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a2bb2o_1
X_2108_ _0443_ _0447_ net201 VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__mux2_1
X_2039_ cn_dn\[0\] _0392_ net225 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1410_ cn_dn\[27\] _0582_ _0583_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__or3_1
X_1341_ _0715_ _0722_ _0734_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a31o_1
X_1272_ _0668_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__or2_1
XFILLER_36_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1539_ _0901_ _0911_ net189 VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__a21o_1
X_1608_ net191 _0819_ _0994_ _0823_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__or4b_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ cn\[27\] net121 net204 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1255_ cn\[16\] _0650_ _0651_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__or3_2
X_1324_ _0719_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ cn\[14\] _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__xor2_2
XFILLER_24_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1942_ cn\[11\] net115 net204 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__mux2_1
XFILLER_9_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1873_ encipher_process _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nor2_1
XFILLER_29_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1307_ _0675_ _0693_ _0699_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a211o_1
X_2287_ clknet_4_14_0_clk _0071_ VGND VGND VPWR VPWR cn_dn\[3\] sky130_fd_sc_hd__dfxtp_1
X_1238_ _0585_ _0622_ _0626_ _0580_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__o31a_1
X_1169_ _0531_ _0552_ _0558_ _0567_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__a31oi_1
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2210_ net140 net247 VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__and2_1
X_2072_ cn_dn\[9\] net75 net207 VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2141_ _0459_ _0463_ net213 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1925_ cn\[5\] _0301_ net228 VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__mux2_1
X_1787_ _0908_ _0917_ _0937_ _0175_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__o211ai_1
X_1856_ _1035_ _0243_ _0246_ _0757_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_29_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2339_ clknet_4_8_0_clk _0123_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dfxtp_1
XFILLER_52_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_60_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_3 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1641_ net192 _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__xnor2_1
X_1572_ _0612_ _0619_ _0625_ _0630_ _0589_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__o311a_1
X_1710_ _0774_ _0781_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__nor2_1
X_2124_ _0458_ _0460_ net256 VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__mux2_1
X_2055_ cn_dn\[3\] _0405_ net225 VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__mux2_1
XFILLER_26_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1908_ _0283_ _0287_ net198 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__mux2_1
X_1839_ _0901_ _0904_ net189 VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__or3_1
XFILLER_17_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1624_ net194 _1010_ _0732_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__a21oi_1
X_1555_ _0698_ _0946_ _0677_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__or3b_1
XFILLER_54_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2107_ cn_dn\[16\] net82 net209 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__mux2_1
XFILLER_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1486_ _0852_ _0853_ _0863_ _0865_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a22o_1
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2038_ _0388_ _0391_ net252 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_60_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1340_ _0733_ _0736_ _0713_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a21o_1
X_1271_ _0665_ _0666_ cn\[2\] VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__a21boi_4
XTAP_TAPCELL_ROW_8_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1538_ _0922_ _0930_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__nand2_1
X_1469_ cn\[8\] _0860_ _0861_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__nand3b_2
X_1607_ _0797_ _0798_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__and2_1
XFILLER_27_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1323_ _0717_ _0718_ cn_dn\[11\] VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21boi_4
XFILLER_5_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1254_ _0650_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__nor2_1
X_1185_ _0582_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__nor2_2
XFILLER_32_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1872_ _0259_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__or2_1
X_1941_ _0299_ _0303_ net212 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__mux2_1
XFILLER_9_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1306_ _0677_ _0687_ _0701_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__a22o_1
X_2286_ clknet_4_11_0_clk _0070_ VGND VGND VPWR VPWR cn_dn\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1237_ _0604_ _0612_ _0590_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__a21o_1
X_1168_ _0531_ _0558_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__nand2_1
XFILLER_20_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2140_ cn_dn\[20\] _0473_ net225 VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__mux2_1
X_2071_ _0403_ _0407_ net214 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1924_ _0298_ _0300_ net251 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__mux2_1
X_1855_ _0787_ _1028_ _0244_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__a22o_1
X_1786_ _0921_ _0177_ _0178_ _0937_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__a31o_1
X_2338_ clknet_4_5_0_clk _0122_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dfxtp_1
XFILLER_29_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2269_ clknet_4_1_0_clk _0053_ VGND VGND VPWR VPWR cn\[13\] sky130_fd_sc_hd__dfxtp_2
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1640_ _0767_ _0774_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__nor2_1
XANTENNA_4 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1571_ _0589_ _0959_ _0961_ _0628_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__a211oi_1
X_2123_ _0455_ _0459_ net201 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2054_ _0402_ _0404_ net253 VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__mux2_1
XFILLER_19_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1907_ cn\[4\] net117 net205 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__mux2_1
X_1838_ _0229_ _0921_ _0175_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__and3b_1
X_1769_ _0161_ _0162_ _0166_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o21ai_1
XFILLER_40_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1623_ _0729_ _0730_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__xnor2_2
X_1554_ _0675_ _0691_ net195 VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__a21oi_1
X_1485_ _0870_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__nor2_1
.ends
